I1 0 1 12.0
R1 1 2 1000.0
R2 2 0 2000.0
R3 2 0 52000.0
R4 2 3 6000.0
R5 3 4 7000.0
R6 4 1 3.0
V1 3 2 1.0
