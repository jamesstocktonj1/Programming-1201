V 0 35 1
R0 0 1 1
R1 0 6 1
R2 6 7 1
R3 6 12 1
R4 12 13 1
R5 12 18 1
R6 18 19 1
R7 18 24 1
R8 24 25 1
R9 24 30 1
R10 30 31 1
R11 30 0 1
R12 1 2 1
R13 1 7 1
R14 7 8 1
R15 7 13 1
R16 13 14 1
R17 13 19 1
R18 19 20 1
R19 19 25 1
R20 25 26 1
R21 25 31 1
R22 31 32 1
R23 31 1 1
R24 2 3 1
R25 2 8 1
R26 8 9 1
R27 8 14 1
R28 14 15 1
R29 14 20 1
R30 20 21 1
R31 20 26 1
R32 26 27 1
R33 26 32 1
R34 32 33 1
R35 32 2 1
R36 3 4 1
R37 3 9 1
R38 9 10 1
R39 9 15 1
R40 15 16 1
R41 15 21 1
R42 21 22 1
R43 21 27 1
R44 27 28 1
R45 27 33 1
R46 33 34 1
R47 33 3 1
R48 4 5 1
R49 4 10 1
R50 10 11 1
R51 10 16 1
R52 16 17 1
R53 16 22 1
R54 22 23 1
R55 22 28 1
R56 28 29 1
R57 28 34 1
R58 34 35 1
R59 34 4 1
R60 5 0 1
R61 5 11 1
R62 11 6 1
R63 11 17 1
R64 17 12 1
R65 17 23 1
R66 23 18 1
R67 23 29 1
R68 29 24 1
R69 29 35 1
R70 35 30 1
R71 35 5 1
