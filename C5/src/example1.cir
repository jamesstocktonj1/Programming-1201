V1 1 0 12.0
R1 1 2 1000.0
R2 2 0 2000.0
R3 2 0 2000.0
