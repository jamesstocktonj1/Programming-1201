V 0 9 1
R0 4 4 1
R1 5 0 1
R2 2 8 1
R3 6 0 1
R4 1 9 1
R5 2 3 1
R6 5 7 1
R7 5 1 1
R8 2 5 1
R9 9 5 1
R10 6 8 1
R11 3 4 1
R12 7 4 1
R13 6 7 1
R14 9 5 1
R15 5 0 1
R16 2 9 1
R17 0 6 1
R18 6 8 1
R19 1 3 1
R20 3 1 1
R21 8 7 1
R22 5 0 1
R23 3 8 1
R24 3 5 1
R25 7 9 1
R26 2 4 1
R27 2 9 1
R28 8 4 1
R29 0 6 1
R30 6 8 1
R31 4 9 1
R32 6 7 1
R33 3 4 1
R34 1 4 1
R35 5 7 1
R36 2 7 1
R37 5 6 1
R38 9 1 1
R39 4 8 1
R40 2 4 1
R41 5 4 1
R42 7 7 1
R43 3 2 1
R44 8 8 1
R45 5 4 1
R46 2 8 1
R47 4 1 1
R48 1 9 1
R49 7 9 1
R50 7 2 1
R51 6 3 1
R52 2 7 1
R53 2 4 1
R54 9 0 1
R55 7 0 1
R56 6 8 1
R57 4 9 1
R58 4 6 1
R59 1 4 1
R60 2 8 1
R61 5 2 1
R62 5 5 1
R63 6 2 1
R64 9 0 1
R65 2 0 1
R66 4 3 1
R67 6 0 1
R68 0 9 1
R69 8 3 1
R70 5 7 1
R71 2 7 1
R72 9 9 1
R73 2 2 1
R74 1 6 1
R75 7 6 1
R76 9 9 1
R77 3 4 1
R78 4 3 1
R79 1 7 1
R80 9 7 1
R81 1 6 1
R82 3 6 1
R83 3 6 1
R84 1 8 1
R85 0 4 1
R86 2 1 1
R87 4 3 1
R88 7 3 1
R89 8 0 1
R90 3 9 1
R91 8 3 1
R92 1 2 1
R93 0 0 1
R94 5 6 1
R95 6 9 1
R96 0 4 1
R97 6 7 1
R98 8 5 1
R99 6 0 1
R100 7 7 1
R101 3 8 1
R102 2 4 1
R103 9 9 1
R104 8 7 1
R105 9 6 1
R106 0 7 1
R107 1 9 1
R108 9 3 1
R109 7 9 1
R110 1 3 1
R111 2 6 1
R112 1 5 1
R113 4 5 1
R114 2 6 1
R115 9 7 1
R116 5 2 1
R117 5 6 1
R118 7 4 1
R119 5 6 1
R120 8 2 1
R121 1 4 1
R122 2 4 1
R123 9 5 1
R124 7 8 1
R125 3 4 1
R126 5 3 1
R127 4 9 1
R128 1 6 1
R129 7 6 1
R130 2 2 1
R131 7 7 1
R132 9 5 1
R133 7 4 1
R134 7 7 1
R135 1 8 1
R136 8 0 1
R137 9 8 1
R138 3 4 1
R139 5 4 1
R140 9 7 1
R141 7 1 1
R142 7 4 1
R143 2 3 1
R144 8 2 1
R145 4 8 1
R146 8 5 1
R147 4 2 1
R148 9 4 1
R149 4 8 1
R150 0 8 1
R151 8 2 1
R152 9 1 1
R153 7 9 1
R154 5 8 1
R155 6 2 1
R156 5 0 1
R157 6 1 1
R158 5 4 1
R159 7 8 1
R160 1 2 1
R161 8 1 1
R162 8 5 1
R163 2 5 1
R164 7 8 1
R165 7 1 1
R166 0 4 1
R167 4 9 1
R168 3 4 1
R169 8 0 1
R170 4 5 1
R171 5 3 1
R172 7 8 1
R173 8 5 1
R174 5 5 1
R175 5 1 1
R176 1 0 1
R177 1 3 1
R178 3 6 1
R179 4 3 1
R180 1 0 1
R181 9 4 1
R182 5 1 1
R183 1 7 1
R184 5 7 1
R185 8 8 1
R186 6 5 1
R187 0 2 1
R188 3 8 1
R189 0 7 1
R190 5 2 1
R191 2 5 1
R192 4 4 1
R193 2 4 1
R194 4 9 1
R195 1 7 1
R196 7 0 1
R197 9 6 1
R198 3 9 1
R199 8 9 1
R200 3 4 1
R201 4 5 1
R202 1 8 1
R203 0 2 1
R204 7 6 1
R205 2 8 1
R206 8 0 1
R207 9 0 1
R208 9 2 1
R209 7 8 1
R210 9 3 1
R211 1 9 1
R212 7 8 1
R213 8 1 1
R214 8 6 1
R215 8 7 1
R216 1 5 1
R217 9 9 1
R218 7 4 1
R219 8 0 1
R220 5 0 1
R221 5 2 1
R222 2 7 1
R223 7 2 1
R224 6 9 1
R225 3 6 1
R226 9 8 1
R227 4 4 1
R228 0 8 1
R229 4 6 1
R230 1 5 1
R231 1 5 1
R232 1 5 1
R233 3 0 1
R234 7 0 1
R235 5 2 1
R236 2 3 1
R237 9 6 1
R238 3 3 1
R239 0 0 1
R240 1 4 1
R241 2 3 1
R242 6 2 1
R243 9 9 1
R244 2 7 1
R245 4 2 1
R246 4 8 1
R247 0 7 1
R248 1 5 1
R249 1 5 1
R250 3 3 1
R251 2 4 1
R252 4 3 1
R253 4 5 1
R254 2 0 1
R255 2 7 1
R256 3 8 1
R257 9 8 1
R258 6 1 1
R259 2 8 1
R260 2 9 1
R261 4 9 1
R262 5 3 1
R263 4 0 1
R264 5 1 1
R265 5 4 1
R266 1 9 1
R267 6 8 1
R268 8 8 1
R269 4 1 1
R270 9 9 1
R271 8 2 1
R272 0 4 1
R273 3 9 1
R274 9 4 1
R275 0 2 1
R276 5 8 1
R277 3 2 1
R278 8 9 1
R279 0 2 1
R280 7 3 1
R281 0 7 1
R282 5 4 1
R283 0 4 1
R284 5 5 1
R285 0 9 1
R286 2 0 1
R287 4 9 1
R288 9 5 1
R289 9 2 1
R290 9 2 1
R291 8 9 1
R292 7 5 1
R293 3 1 1
R294 7 3 1
R295 1 5 1
R296 2 9 1
R297 2 1 1
R298 5 4 1
R299 6 2 1
R300 1 2 1
R301 8 0 1
R302 7 9 1
R303 5 0 1
R304 0 8 1
R305 4 2 1
R306 8 5 1
R307 1 2 1
R308 6 3 1
R309 9 4 1
R310 6 9 1
R311 5 6 1
R312 6 8 1
R313 6 2 1
R314 9 6 1
R315 3 6 1
R316 4 6 1
R317 8 6 1
R318 7 3 1
R319 9 1 1
R320 0 2 1
R321 2 0 1
R322 2 9 1
R323 0 6 1
R324 7 4 1
R325 4 8 1
R326 1 1 1
R327 0 4 1
R328 0 1 1
R329 5 3 1
R330 9 0 1
R331 3 0 1
R332 5 7 1
R333 0 1 1
R334 4 5 1
R335 2 0 1
R336 3 8 1
R337 6 5 1
R338 7 8 1
R339 0 1 1
R340 9 4 1
R341 0 9 1
R342 5 4 1
R343 3 5 1
R344 1 4 1
R345 4 3 1
R346 6 2 1
R347 7 6 1
R348 9 1 1
R349 7 7 1
R350 2 1 1
R351 6 1 1
R352 3 6 1
R353 0 5 1
R354 2 9 1
R355 2 3 1
R356 6 6 1
R357 8 3 1
R358 0 4 1
R359 2 8 1
R360 3 3 1
R361 4 4 1
R362 6 9 1
R363 3 1 1
R364 4 9 1
R365 8 7 1
R366 8 3 1
R367 7 4 1
R368 4 6 1
R369 3 4 1
R370 5 6 1
R371 8 5 1
R372 3 2 1
R373 8 6 1
R374 4 7 1
R375 8 6 1
R376 8 4 1
R377 6 1 1
R378 3 8 1
R379 9 6 1
R380 9 1 1
R381 4 1 1
R382 8 5 1
R383 4 7 1
R384 0 8 1
R385 9 8 1
R386 0 5 1
R387 3 8 1
R388 8 0 1
R389 9 9 1
R390 7 1 1
R391 0 1 1
R392 3 8 1
R393 1 9 1
R394 3 1 1
R395 9 4 1
R396 4 3 1
R397 2 1 1
R398 2 6 1
R399 0 4 1
R400 4 3 1
R401 3 3 1
R402 9 5 1
R403 9 1 1
R404 9 2 1
R405 9 3 1
R406 5 7 1
R407 9 2 1
R408 9 9 1
R409 7 7 1
R410 6 6 1
R411 2 9 1
R412 1 0 1
R413 2 0 1
R414 8 5 1
R415 6 5 1
R416 1 2 1
R417 0 9 1
R418 4 0 1
R419 4 9 1
R420 6 3 1
R421 7 6 1
R422 2 6 1
R423 0 8 1
R424 0 5 1
R425 3 9 1
R426 4 2 1
R427 0 7 1
R428 0 8 1
R429 6 5 1
R430 8 7 1
R431 4 0 1
R432 5 7 1
R433 4 6 1
R434 5 5 1
R435 5 8 1
R436 9 9 1
R437 8 3 1
R438 8 2 1
R439 2 1 1
R440 1 9 1
R441 8 9 1
R442 5 7 1
R443 9 3 1
R444 1 9 1
R445 9 6 1
R446 9 1 1
R447 7 9 1
R448 7 0 1
R449 2 2 1
R450 8 2 1
R451 7 2 1
R452 4 8 1
R453 7 9 1
R454 9 7 1
R455 8 5 1
R456 6 4 1
R457 5 6 1
R458 7 3 1
R459 1 8 1
R460 6 4 1
R461 7 5 1
R462 2 7 1
R463 0 1 1
R464 5 5 1
R465 0 5 1
R466 0 5 1
R467 4 8 1
R468 3 2 1
R469 9 4 1
R470 1 3 1
R471 4 5 1
R472 3 0 1
R473 3 1 1
R474 1 0 1
R475 7 9 1
R476 6 5 1
R477 9 9 1
R478 7 9 1
R479 0 7 1
R480 9 9 1
R481 5 0 1
R482 5 3 1
R483 2 5 1
R484 7 9 1
R485 0 7 1
R486 3 3 1
R487 3 4 1
R488 2 3 1
R489 5 4 1
R490 5 7 1
R491 1 6 1
R492 7 9 1
R493 6 5 1
R494 1 2 1
R495 2 4 1
R496 1 2 1
R497 1 0 1
R498 3 4 1
R499 4 0 1
R500 6 8 1
R501 9 6 1
R502 9 1 1
R503 0 1 1
R504 5 3 1
R505 6 0 1
R506 8 5 1
R507 9 0 1
R508 4 6 1
R509 3 2 1
R510 2 9 1
R511 6 6 1
R512 5 2 1
R513 7 2 1
R514 0 7 1
R515 0 5 1
R516 5 0 1
R517 0 6 1
R518 5 7 1
R519 4 1 1
R520 2 6 1
R521 5 8 1
R522 9 6 1
R523 5 8 1
R524 8 0 1
R525 7 7 1
R526 2 4 1
R527 9 7 1
R528 9 2 1
R529 2 8 1
R530 8 0 1
R531 3 2 1
R532 3 8 1
R533 3 0 1
R534 7 9 1
R535 0 2 1
R536 7 2 1
R537 0 8 1
R538 8 2 1
R539 4 6 1
R540 3 8 1
R541 4 6 1
R542 5 5 1
R543 9 2 1
R544 8 9 1
R545 1 2 1
R546 7 1 1
R547 2 9 1
R548 4 8 1
R549 7 6 1
R550 5 9 1
R551 1 0 1
R552 7 7 1
R553 6 1 1
R554 9 3 1
R555 4 5 1
R556 5 0 1
R557 7 5 1
R558 3 5 1
R559 4 4 1
R560 0 5 1
R561 9 9 1
R562 5 3 1
R563 0 4 1
R564 0 8 1
R565 3 5 1
R566 9 4 1
R567 4 8 1
R568 8 5 1
R569 5 6 1
R570 5 2 1
R571 0 7 1
R572 2 1 1
R573 8 1 1
R574 6 6 1
R575 1 1 1
R576 8 6 1
R577 2 0 1
R578 2 2 1
R579 0 3 1
R580 0 3 1
R581 8 2 1
R582 9 5 1
R583 2 3 1
R584 8 0 1
R585 7 1 1
R586 4 3 1
R587 2 2 1
R588 2 5 1
R589 2 5 1
R590 7 0 1
R591 3 0 1
R592 1 5 1
R593 1 4 1
R594 8 0 1
R595 3 7 1
R596 5 7 1
R597 7 1 1
R598 4 9 1
R599 7 9 1
R600 7 8 1
R601 9 7 1
R602 3 4 1
R603 9 5 1
R604 6 4 1
R605 3 8 1
R606 8 2 1
R607 5 0 1
R608 5 8 1
R609 2 0 1
R610 0 6 1
R611 4 7 1
R612 1 4 1
R613 0 2 1
R614 0 2 1
R615 8 7 1
R616 7 4 1
R617 8 9 1
R618 8 4 1
R619 8 0 1
R620 4 1 1
R621 6 8 1
R622 0 2 1
R623 2 3 1
R624 2 9 1
R625 2 0 1
R626 8 1 1
R627 1 0 1
R628 3 5 1
R629 9 8 1
R630 1 0 1
R631 7 6 1
R632 2 1 1
R633 2 5 1
R634 4 0 1
R635 8 1 1
R636 2 2 1
R637 4 9 1
R638 4 6 1
R639 4 8 1
R640 1 4 1
R641 9 0 1
R642 3 0 1
R643 3 4 1
R644 5 0 1
R645 9 5 1
R646 9 7 1
R647 6 0 1
R648 4 9 1
R649 4 1 1
R650 1 0 1
R651 6 6 1
R652 3 3 1
R653 5 9 1
R654 2 5 1
R655 3 8 1
R656 7 0 1
R657 4 9 1
R658 0 7 1
R659 3 2 1
R660 9 8 1
R661 4 7 1
R662 0 2 1
R663 8 8 1
R664 4 0 1
R665 8 6 1
R666 1 8 1
R667 7 4 1
R668 7 5 1
R669 5 4 1
R670 4 5 1
R671 2 7 1
R672 2 2 1
R673 4 8 1
R674 8 8 1
R675 4 6 1
R676 3 9 1
R677 7 8 1
R678 8 8 1
R679 6 9 1
R680 5 1 1
R681 9 3 1
R682 2 5 1
R683 8 0 1
R684 0 5 1
R685 7 0 1
R686 2 9 1
R687 7 6 1
R688 7 8 1
R689 1 7 1
R690 0 3 1
R691 5 5 1
R692 1 3 1
R693 7 7 1
R694 3 5 1
R695 4 5 1
R696 1 2 1
R697 9 9 1
R698 0 9 1
R699 1 6 1
R700 2 2 1
R701 9 9 1
R702 6 5 1
R703 9 5 1
R704 4 4 1
R705 4 8 1
R706 8 6 1
R707 1 6 1
R708 3 1 1
R709 8 4 1
R710 3 1 1
R711 7 2 1
R712 9 7 1
R713 1 9 1
R714 4 4 1
R715 7 7 1
R716 2 6 1
R717 2 7 1
R718 9 1 1
R719 3 3 1
R720 7 8 1
R721 9 8 1
R722 5 0 1
R723 7 5 1
R724 5 5 1
R725 4 6 1
R726 8 0 1
R727 9 7 1
R728 3 4 1
R729 2 5 1
R730 2 2 1
R731 1 0 1
R732 8 5 1
R733 7 6 1
R734 9 0 1
R735 0 1 1
R736 4 5 1
R737 1 9 1
R738 8 5 1
R739 0 3 1
R740 1 6 1
R741 8 8 1
R742 3 1 1
R743 7 5 1
R744 7 0 1
R745 4 1 1
R746 5 2 1
R747 2 1 1
R748 2 9 1
R749 7 1 1
R750 0 2 1
R751 1 3 1
R752 9 5 1
R753 4 5 1
R754 5 7 1
R755 7 4 1
R756 4 4 1
R757 8 9 1
R758 8 5 1
R759 1 7 1
R760 9 4 1
R761 5 4 1
R762 0 9 1
R763 5 5 1
R764 9 0 1
R765 5 5 1
R766 6 7 1
R767 6 0 1
R768 4 4 1
R769 3 6 1
R770 3 8 1
R771 8 3 1
R772 8 3 1
R773 9 1 1
R774 3 8 1
R775 6 0 1
R776 1 4 1
R777 4 1 1
R778 9 9 1
R779 1 4 1
R780 9 7 1
R781 4 9 1
R782 5 6 1
R783 6 9 1
R784 9 3 1
R785 7 3 1
R786 2 1 1
R787 6 9 1
R788 9 4 1
R789 6 0 1
R790 0 0 1
R791 1 4 1
R792 8 0 1
R793 5 6 1
R794 8 8 1
R795 5 9 1
R796 0 9 1
R797 1 3 1
R798 5 2 1
R799 3 6 1
R800 4 9 1
R801 9 9 1
R802 8 2 1
R803 0 6 1
R804 5 9 1
R805 6 3 1
R806 3 9 1
R807 5 1 1
R808 6 8 1
R809 7 6 1
R810 5 6 1
R811 1 9 1
R812 0 1 1
R813 9 1 1
R814 4 7 1
R815 0 5 1
R816 4 4 1
R817 0 8 1
R818 0 5 1
R819 1 5 1
R820 2 2 1
R821 2 5 1
R822 8 7 1
R823 7 6 1
R824 0 7 1
R825 3 4 1
R826 0 2 1
R827 8 8 1
R828 7 2 1
R829 2 4 1
R830 4 9 1
R831 1 0 1
R832 5 2 1
R833 0 2 1
R834 6 3 1
R835 2 5 1
R836 4 6 1
R837 7 3 1
R838 9 9 1
R839 9 8 1
R840 9 0 1
R841 8 2 1
R842 4 2 1
R843 8 1 1
R844 0 2 1
R845 3 5 1
R846 5 6 1
R847 1 7 1
R848 2 6 1
R849 4 1 1
R850 9 1 1
R851 8 6 1
R852 3 5 1
R853 2 7 1
R854 9 0 1
R855 4 5 1
R856 3 3 1
R857 3 6 1
R858 9 0 1
R859 9 9 1
R860 8 7 1
R861 3 4 1
R862 6 8 1
R863 5 4 1
R864 6 6 1
R865 4 2 1
R866 1 7 1
R867 0 1 1
R868 0 1 1
R869 8 8 1
R870 2 6 1
R871 0 6 1
R872 6 0 1
R873 3 9 1
R874 8 3 1
R875 0 2 1
R876 5 9 1
R877 1 2 1
R878 9 8 1
R879 7 7 1
R880 4 4 1
R881 3 1 1
R882 3 5 1
R883 8 5 1
R884 3 1 1
R885 9 3 1
R886 6 3 1
R887 3 2 1
R888 6 9 1
R889 7 2 1
R890 9 1 1
R891 0 6 1
R892 2 3 1
R893 2 8 1
R894 9 9 1
R895 6 8 1
R896 1 6 1
R897 1 8 1
R898 1 2 1
R899 1 8 1
R900 8 5 1
R901 8 0 1
R902 7 6 1
R903 8 5 1
R904 5 9 1
R905 8 6 1
R906 5 1 1
R907 5 8 1
R908 7 2 1
R909 7 7 1
R910 1 7 1
R911 6 9 1
R912 5 7 1
R913 7 8 1
R914 1 0 1
R915 0 8 1
R916 3 2 1
R917 9 7 1
R918 5 3 1
R919 4 6 1
R920 2 6 1
R921 2 6 1
R922 0 2 1
R923 7 7 1
R924 2 6 1
R925 1 7 1
R926 1 2 1
R927 8 7 1
R928 5 6 1
R929 0 4 1
R930 7 3 1
R931 0 4 1
R932 0 6 1
R933 6 5 1
R934 0 0 1
R935 9 2 1
R936 1 8 1
R937 8 8 1
R938 1 7 1
R939 7 8 1
R940 3 3 1
R941 6 0 1
R942 3 4 1
R943 0 9 1
R944 4 5 1
R945 0 8 1
R946 7 0 1
R947 0 1 1
R948 5 1 1
R949 6 5 1
R950 8 2 1
R951 1 7 1
R952 5 6 1
R953 5 4 1
R954 0 2 1
R955 5 6 1
R956 2 4 1
R957 1 3 1
R958 8 0 1
R959 1 8 1
R960 4 6 1
R961 0 8 1
R962 6 5 1
R963 5 8 1
R964 8 4 1
R965 8 4 1
R966 1 9 1
R967 3 5 1
R968 2 3 1
R969 8 7 1
R970 0 7 1
R971 6 9 1
R972 5 1 1
R973 6 9 1
R974 1 3 1
R975 2 8 1
R976 8 1 1
R977 0 3 1
R978 3 0 1
R979 0 8 1
R980 9 1 1
R981 0 0 1
R982 8 7 1
R983 3 7 1
R984 9 3 1
R985 4 2 1
R986 7 2 1
R987 0 1 1
R988 4 6 1
R989 5 5 1
R990 2 1 1
R991 4 6 1
R992 4 1 1
R993 1 7 1
R994 2 8 1
R995 6 7 1
R996 8 6 1
R997 0 7 1
R998 1 3 1
R999 2 2 1
R1000 2 8 1
R1001 8 8 1
R1002 8 9 1
R1003 1 3 1
R1004 4 7 1
R1005 9 5 1
R1006 8 6 1
R1007 6 2 1
R1008 8 4 1
R1009 3 2 1
R1010 2 1 1
R1011 2 1 1
R1012 0 8 1
R1013 9 9 1
R1014 1 8 1
R1015 4 5 1
R1016 9 0 1
R1017 1 7 1
R1018 9 8 1
R1019 5 4 1
R1020 7 9 1
R1021 1 6 1
R1022 7 0 1
R1023 2 1 1
R1024 8 8 1
R1025 3 0 1
R1026 7 5 1
R1027 8 3 1
R1028 5 4 1
R1029 1 1 1
R1030 1 8 1
R1031 1 1 1
R1032 5 1 1
R1033 6 1 1
R1034 4 1 1
R1035 4 4 1
R1036 7 3 1
R1037 5 6 1
R1038 1 0 1
R1039 9 4 1
R1040 9 8 1
R1041 8 6 1
R1042 3 1 1
R1043 3 8 1
R1044 3 1 1
R1045 3 4 1
R1046 9 3 1
R1047 2 2 1
R1048 8 5 1
R1049 9 0 1
R1050 7 6 1
R1051 5 6 1
R1052 8 1 1
R1053 5 4 1
R1054 2 2 1
R1055 5 5 1
R1056 7 5 1
R1057 5 9 1
R1058 0 4 1
R1059 8 0 1
R1060 8 6 1
R1061 0 5 1
R1062 3 5 1
R1063 0 8 1
R1064 9 0 1
R1065 5 2 1
R1066 8 9 1
R1067 7 3 1
R1068 6 5 1
R1069 6 9 1
R1070 8 4 1
R1071 5 1 1
R1072 9 9 1
R1073 9 9 1
R1074 2 0 1
R1075 4 0 1
R1076 2 6 1
R1077 5 3 1
R1078 4 7 1
R1079 5 8 1
R1080 0 4 1
R1081 8 1 1
R1082 7 9 1
R1083 3 7 1
R1084 7 1 1
R1085 4 5 1
R1086 9 3 1
R1087 1 8 1
R1088 0 0 1
R1089 6 5 1
R1090 2 9 1
R1091 8 1 1
R1092 3 2 1
R1093 1 2 1
R1094 1 5 1
R1095 9 5 1
R1096 6 7 1
R1097 6 2 1
R1098 0 1 1
R1099 3 9 1
R1100 1 0 1
R1101 8 3 1
R1102 8 5 1
R1103 2 1 1
R1104 6 3 1
R1105 7 8 1
R1106 8 3 1
R1107 9 5 1
R1108 9 9 1
R1109 1 2 1
R1110 2 3 1
R1111 7 1 1
R1112 1 1 1
R1113 6 4 1
R1114 8 6 1
R1115 8 0 1
R1116 9 5 1
R1117 0 5 1
R1118 3 9 1
R1119 5 3 1
R1120 7 6 1
R1121 6 2 1
R1122 7 1 1
R1123 2 4 1
R1124 5 8 1
R1125 4 5 1
R1126 8 8 1
R1127 9 3 1
R1128 1 1 1
R1129 7 6 1
R1130 5 8 1
R1131 5 8 1
R1132 8 1 1
R1133 4 0 1
R1134 1 2 1
R1135 1 4 1
R1136 1 9 1
R1137 2 6 1
R1138 4 5 1
R1139 3 7 1
R1140 5 7 1
R1141 4 9 1
R1142 9 6 1
R1143 4 6 1
R1144 5 2 1
R1145 5 4 1
R1146 5 9 1
R1147 1 4 1
R1148 0 3 1
R1149 6 1 1
R1150 9 5 1
R1151 7 1 1
R1152 0 4 1
R1153 3 8 1
R1154 3 3 1
R1155 5 8 1
R1156 9 6 1
R1157 6 7 1
R1158 7 0 1
R1159 5 6 1
R1160 2 2 1
R1161 3 5 1
R1162 0 2 1
R1163 3 8 1
R1164 4 4 1
R1165 8 2 1
R1166 7 4 1
R1167 3 1 1
R1168 9 0 1
R1169 0 5 1
R1170 4 8 1
R1171 7 9 1
R1172 9 7 1
R1173 3 8 1
R1174 8 0 1
R1175 7 8 1
R1176 4 7 1
R1177 5 5 1
R1178 2 3 1
R1179 9 1 1
R1180 8 1 1
R1181 3 8 1
R1182 1 7 1
R1183 6 6 1
R1184 9 8 1
R1185 8 0 1
R1186 3 4 1
R1187 4 6 1
R1188 3 5 1
R1189 6 8 1
R1190 8 0 1
R1191 1 7 1
R1192 4 0 1
R1193 8 3 1
R1194 7 6 1
R1195 0 2 1
R1196 2 7 1
R1197 2 6 1
R1198 2 8 1
R1199 9 6 1
R1200 0 4 1
R1201 1 5 1
R1202 6 6 1
R1203 5 8 1
R1204 3 5 1
R1205 8 8 1
R1206 5 9 1
R1207 8 1 1
R1208 6 1 1
R1209 4 8 1
R1210 3 4 1
R1211 4 1 1
R1212 4 9 1
R1213 3 2 1
R1214 3 1 1
R1215 9 4 1
R1216 5 4 1
R1217 0 5 1
R1218 1 5 1
R1219 7 9 1
R1220 3 5 1
R1221 8 5 1
R1222 7 3 1
R1223 9 8 1
R1224 5 6 1
R1225 0 2 1
R1226 8 4 1
R1227 0 3 1
R1228 7 3 1
R1229 3 5 1
R1230 6 0 1
R1231 3 4 1
R1232 8 4 1
R1233 5 2 1
R1234 6 6 1
R1235 1 6 1
R1236 9 7 1
R1237 7 5 1
R1238 7 9 1
R1239 8 5 1
R1240 9 1 1
R1241 1 4 1
R1242 9 8 1
R1243 4 2 1
R1244 1 3 1
R1245 4 2 1
R1246 4 3 1
R1247 2 2 1
R1248 7 3 1
R1249 7 9 1
R1250 4 7 1
R1251 4 4 1
R1252 5 1 1
R1253 2 5 1
R1254 5 7 1
R1255 6 3 1
R1256 1 5 1
R1257 4 6 1
R1258 2 6 1
R1259 3 3 1
R1260 3 6 1
R1261 4 9 1
R1262 9 3 1
R1263 7 0 1
R1264 6 1 1
R1265 6 9 1
R1266 3 9 1
R1267 0 0 1
R1268 0 2 1
R1269 4 5 1
R1270 6 3 1
R1271 8 7 1
R1272 6 7 1
R1273 0 9 1
R1274 6 8 1
R1275 0 1 1
R1276 0 2 1
R1277 8 0 1
R1278 5 9 1
R1279 5 7 1
R1280 7 0 1
R1281 9 0 1
R1282 1 5 1
R1283 8 4 1
R1284 0 8 1
R1285 5 6 1
R1286 7 6 1
R1287 5 4 1
R1288 0 3 1
R1289 5 0 1
R1290 0 6 1
R1291 2 8 1
R1292 6 5 1
R1293 7 6 1
R1294 8 3 1
R1295 9 5 1
R1296 8 5 1
R1297 5 3 1
R1298 0 9 1
R1299 0 4 1
R1300 2 3 1
R1301 4 3 1
R1302 2 8 1
R1303 8 2 1
R1304 4 3 1
R1305 6 9 1
R1306 4 3 1
R1307 0 5 1
R1308 4 2 1
R1309 1 6 1
R1310 0 3 1
R1311 3 5 1
R1312 4 9 1
R1313 7 3 1
R1314 2 7 1
R1315 0 2 1
R1316 3 0 1
R1317 6 4 1
R1318 1 3 1
R1319 0 3 1
R1320 6 5 1
R1321 0 5 1
R1322 4 6 1
R1323 0 1 1
R1324 1 3 1
R1325 9 7 1
R1326 5 8 1
R1327 8 4 1
R1328 7 6 1
R1329 4 4 1
R1330 1 8 1
R1331 3 0 1
R1332 2 0 1
R1333 4 2 1
R1334 5 4 1
R1335 4 4 1
R1336 1 8 1
R1337 2 1 1
R1338 1 1 1
R1339 7 8 1
R1340 4 5 1
R1341 7 4 1
R1342 5 2 1
R1343 9 5 1
R1344 0 0 1
R1345 0 7 1
R1346 9 4 1
R1347 8 0 1
R1348 8 9 1
R1349 1 8 1
R1350 3 9 1
R1351 4 4 1
R1352 9 3 1
R1353 3 1 1
R1354 2 0 1
R1355 8 3 1
R1356 2 6 1
R1357 9 9 1
R1358 6 5 1
R1359 9 2 1
R1360 4 6 1
R1361 6 3 1
R1362 5 6 1
R1363 5 8 1
R1364 5 9 1
R1365 9 0 1
R1366 3 0 1
R1367 5 1 1
R1368 0 0 1
R1369 0 0 1
R1370 5 4 1
R1371 8 7 1
R1372 5 4 1
R1373 4 2 1
R1374 9 4 1
R1375 5 7 1
R1376 5 2 1
R1377 6 8 1
R1378 9 0 1
R1379 9 8 1
R1380 6 4 1
R1381 7 6 1
R1382 6 6 1
R1383 3 0 1
R1384 4 7 1
R1385 2 8 1
R1386 9 7 1
R1387 8 8 1
R1388 6 0 1
R1389 4 0 1
R1390 0 5 1
R1391 8 6 1
R1392 3 8 1
R1393 3 7 1
R1394 6 0 1
R1395 4 6 1
R1396 7 8 1
R1397 9 9 1
R1398 0 7 1
R1399 1 6 1
R1400 5 6 1
R1401 0 0 1
R1402 4 5 1
R1403 3 5 1
R1404 7 2 1
R1405 9 2 1
R1406 6 0 1
R1407 3 5 1
R1408 0 4 1
R1409 5 2 1
R1410 1 5 1
R1411 7 3 1
R1412 3 3 1
R1413 2 2 1
R1414 1 6 1
R1415 1 1 1
R1416 7 6 1
R1417 7 3 1
R1418 2 5 1
R1419 4 1 1
R1420 6 0 1
R1421 7 0 1
R1422 8 4 1
R1423 0 2 1
R1424 8 3 1
R1425 3 6 1
R1426 6 7 1
R1427 0 6 1
R1428 4 9 1
R1429 4 6 1
R1430 3 3 1
R1431 6 6 1
R1432 8 1 1
R1433 3 7 1
R1434 9 9 1
R1435 2 0 1
R1436 5 1 1
R1437 7 7 1
R1438 4 9 1
R1439 8 2 1
R1440 4 2 1
R1441 8 6 1
R1442 7 0 1
R1443 6 2 1
R1444 3 6 1
R1445 4 0 1
R1446 2 0 1
R1447 9 3 1
R1448 7 1 1
R1449 1 3 1
R1450 5 3 1
R1451 6 4 1
R1452 6 1 1
R1453 1 8 1
R1454 8 2 1
R1455 0 2 1
R1456 2 7 1
R1457 4 8 1
R1458 7 2 1
R1459 8 5 1
R1460 5 4 1
R1461 7 4 1
R1462 4 8 1
R1463 4 5 1
R1464 0 7 1
R1465 4 8 1
R1466 2 8 1
R1467 6 8 1
R1468 7 6 1
R1469 4 5 1
R1470 1 5 1
R1471 9 5 1
R1472 0 8 1
R1473 0 7 1
R1474 5 6 1
R1475 7 9 1
R1476 8 3 1
R1477 0 8 1
R1478 1 1 1
R1479 6 7 1
R1480 1 0 1
R1481 5 0 1
R1482 5 6 1
R1483 9 1 1
R1484 2 7 1
R1485 2 1 1
R1486 9 6 1
R1487 0 3 1
R1488 6 9 1
R1489 2 6 1
R1490 1 7 1
R1491 2 3 1
R1492 3 3 1
R1493 4 1 1
R1494 0 2 1
R1495 9 7 1
R1496 8 4 1
R1497 1 5 1
R1498 8 2 1
R1499 2 6 1
R1500 1 8 1
R1501 4 1 1
R1502 9 6 1
R1503 4 8 1
R1504 4 9 1
R1505 5 3 1
R1506 4 5 1
R1507 3 6 1
R1508 2 2 1
R1509 9 2 1
R1510 9 1 1
R1511 0 8 1
R1512 1 3 1
R1513 7 7 1
R1514 6 2 1
R1515 0 5 1
R1516 1 8 1
R1517 3 1 1
R1518 9 5 1
R1519 2 5 1
R1520 4 2 1
R1521 5 6 1
R1522 8 6 1
R1523 7 2 1
R1524 6 1 1
R1525 0 9 1
R1526 7 4 1
R1527 1 1 1
R1528 0 7 1
R1529 6 0 1
R1530 2 2 1
R1531 2 6 1
R1532 4 9 1
R1533 0 3 1
R1534 8 5 1
R1535 3 1 1
R1536 2 4 1
R1537 1 8 1
R1538 5 0 1
R1539 0 6 1
R1540 9 1 1
R1541 3 5 1
R1542 3 2 1
R1543 1 6 1
R1544 9 2 1
R1545 9 4 1
R1546 8 9 1
R1547 9 1 1
R1548 3 5 1
R1549 4 0 1
R1550 8 5 1
R1551 6 9 1
R1552 0 4 1
R1553 8 8 1
R1554 3 4 1
R1555 1 9 1
R1556 8 9 1
R1557 9 5 1
R1558 9 3 1
R1559 5 8 1
R1560 0 8 1
R1561 3 3 1
R1562 2 7 1
R1563 4 0 1
R1564 3 5 1
R1565 1 1 1
R1566 1 9 1
R1567 9 0 1
R1568 8 7 1
R1569 7 3 1
R1570 8 9 1
R1571 4 1 1
R1572 2 1 1
R1573 8 7 1
R1574 1 5 1
R1575 0 6 1
R1576 7 3 1
R1577 2 9 1
R1578 2 5 1
R1579 1 7 1
R1580 8 5 1
R1581 6 5 1
R1582 3 7 1
R1583 9 2 1
R1584 5 9 1
R1585 9 2 1
R1586 6 2 1
R1587 4 7 1
R1588 8 7 1
R1589 7 0 1
R1590 2 9 1
R1591 7 6 1
R1592 1 7 1
R1593 1 2 1
R1594 6 9 1
R1595 1 8 1
R1596 6 6 1
R1597 9 2 1
R1598 1 4 1
R1599 5 1 1
R1600 1 4 1
R1601 2 1 1
R1602 9 6 1
R1603 4 2 1
R1604 5 2 1
R1605 5 3 1
R1606 9 5 1
R1607 2 7 1
R1608 8 0 1
R1609 9 2 1
R1610 9 5 1
R1611 2 5 1
R1612 6 4 1
R1613 5 9 1
R1614 7 7 1
R1615 8 2 1
R1616 5 5 1
R1617 5 8 1
R1618 1 8 1
R1619 4 0 1
R1620 9 6 1
R1621 0 4 1
R1622 0 1 1
R1623 6 9 1
R1624 8 2 1
R1625 9 3 1
R1626 6 6 1
R1627 7 8 1
R1628 0 7 1
R1629 6 3 1
R1630 6 4 1
R1631 5 8 1
R1632 4 8 1
R1633 6 0 1
R1634 3 1 1
R1635 1 2 1
R1636 3 9 1
R1637 7 2 1
R1638 8 0 1
R1639 2 7 1
R1640 3 0 1
R1641 4 7 1
R1642 9 2 1
R1643 2 2 1
R1644 7 6 1
R1645 1 4 1
R1646 5 5 1
R1647 5 9 1
R1648 9 9 1
R1649 2 2 1
R1650 7 2 1
R1651 9 5 1
R1652 8 0 1
R1653 0 0 1
R1654 9 9 1
R1655 5 6 1
R1656 7 7 1
R1657 8 9 1
R1658 5 9 1
R1659 9 6 1
R1660 3 1 1
R1661 1 7 1
R1662 8 7 1
R1663 7 2 1
R1664 1 2 1
R1665 9 8 1
R1666 5 6 1
R1667 3 3 1
R1668 6 7 1
R1669 4 0 1
R1670 1 4 1
R1671 1 4 1
R1672 2 3 1
R1673 4 6 1
R1674 0 0 1
R1675 6 3 1
R1676 1 6 1
R1677 3 6 1
R1678 8 0 1
R1679 9 4 1
R1680 4 2 1
R1681 8 7 1
R1682 1 1 1
R1683 9 4 1
R1684 4 9 1
R1685 5 2 1
R1686 6 1 1
R1687 4 6 1
R1688 8 0 1
R1689 0 7 1
R1690 8 7 1
R1691 8 9 1
R1692 1 8 1
R1693 8 2 1
R1694 0 8 1
R1695 2 7 1
R1696 1 8 1
R1697 8 0 1
R1698 5 1 1
R1699 6 7 1
R1700 0 0 1
R1701 2 5 1
R1702 0 8 1
R1703 6 2 1
R1704 0 9 1
R1705 7 4 1
R1706 9 6 1
R1707 5 0 1
R1708 7 2 1
R1709 0 6 1
R1710 3 7 1
R1711 2 1 1
R1712 9 6 1
R1713 1 1 1
R1714 9 5 1
R1715 9 3 1
R1716 0 6 1
R1717 8 6 1
R1718 1 1 1
R1719 7 9 1
R1720 8 2 1
R1721 7 3 1
R1722 6 2 1
R1723 1 1 1
R1724 3 5 1
R1725 6 2 1
R1726 2 2 1
R1727 5 9 1
R1728 6 2 1
R1729 6 5 1
R1730 5 1 1
R1731 7 7 1
R1732 1 0 1
R1733 2 6 1
R1734 9 5 1
R1735 0 6 1
R1736 4 9 1
R1737 3 3 1
R1738 3 9 1
R1739 0 1 1
R1740 5 9 1
R1741 1 8 1
R1742 1 7 1
R1743 0 4 1
R1744 1 4 1
R1745 5 5 1
R1746 8 3 1
R1747 3 8 1
R1748 3 4 1
R1749 5 7 1
R1750 5 3 1
R1751 3 5 1
R1752 2 6 1
R1753 6 3 1
R1754 1 2 1
R1755 5 1 1
R1756 4 0 1
R1757 8 7 1
R1758 9 8 1
R1759 4 5 1
R1760 4 7 1
R1761 9 7 1
R1762 4 2 1
R1763 1 4 1
R1764 9 5 1
R1765 5 9 1
R1766 1 7 1
R1767 5 9 1
R1768 2 0 1
R1769 3 7 1
R1770 4 7 1
R1771 4 3 1
R1772 6 0 1
R1773 2 9 1
R1774 0 7 1
R1775 3 1 1
R1776 1 3 1
R1777 8 3 1
R1778 9 6 1
R1779 4 9 1
R1780 7 9 1
R1781 9 0 1
R1782 0 9 1
R1783 6 7 1
R1784 2 2 1
R1785 7 2 1
R1786 3 0 1
R1787 1 0 1
R1788 4 1 1
R1789 4 0 1
R1790 8 6 1
R1791 7 2 1
R1792 0 6 1
R1793 9 6 1
R1794 1 0 1
R1795 4 0 1
R1796 8 6 1
R1797 6 0 1
R1798 7 6 1
R1799 0 9 1
R1800 0 6 1
R1801 2 7 1
R1802 0 6 1
R1803 0 7 1
R1804 1 1 1
R1805 5 0 1
R1806 9 6 1
R1807 9 0 1
R1808 2 7 1
R1809 7 9 1
R1810 2 6 1
R1811 2 6 1
R1812 2 7 1
R1813 9 9 1
R1814 2 8 1
R1815 4 3 1
R1816 4 4 1
R1817 5 2 1
R1818 7 3 1
R1819 6 6 1
R1820 7 8 1
R1821 6 0 1
R1822 3 6 1
R1823 3 6 1
R1824 9 1 1
R1825 3 7 1
R1826 4 2 1
R1827 2 7 1
R1828 3 8 1
R1829 4 1 1
R1830 1 3 1
R1831 5 5 1
R1832 3 4 1
R1833 3 8 1
R1834 7 7 1
R1835 9 8 1
R1836 4 0 1
R1837 6 5 1
R1838 6 1 1
R1839 8 9 1
R1840 6 4 1
R1841 0 3 1
R1842 9 9 1
R1843 7 8 1
R1844 3 1 1
R1845 7 8 1
R1846 5 0 1
R1847 5 4 1
R1848 1 3 1
R1849 1 6 1
R1850 1 3 1
R1851 2 7 1
R1852 6 5 1
R1853 5 9 1
R1854 2 1 1
R1855 1 5 1
R1856 8 0 1
R1857 2 7 1
R1858 3 5 1
R1859 0 0 1
R1860 6 6 1
R1861 8 4 1
R1862 5 0 1
R1863 4 4 1
R1864 1 4 1
R1865 1 0 1
R1866 1 0 1
R1867 5 5 1
R1868 3 9 1
R1869 8 8 1
R1870 3 2 1
R1871 5 9 1
R1872 9 8 1
R1873 4 1 1
R1874 4 0 1
R1875 9 7 1
R1876 5 0 1
R1877 9 7 1
R1878 5 4 1
R1879 3 1 1
R1880 8 5 1
R1881 1 3 1
R1882 8 8 1
R1883 7 7 1
R1884 2 4 1
R1885 4 0 1
R1886 2 1 1
R1887 3 4 1
R1888 1 2 1
R1889 6 0 1
R1890 1 5 1
R1891 7 6 1
R1892 2 4 1
R1893 3 1 1
R1894 2 0 1
R1895 4 2 1
R1896 8 6 1
R1897 7 2 1
R1898 6 1 1
R1899 7 9 1
R1900 1 6 1
R1901 6 1 1
R1902 5 6 1
R1903 2 6 1
R1904 0 0 1
R1905 1 3 1
R1906 8 2 1
R1907 0 1 1
R1908 2 4 1
R1909 0 4 1
R1910 8 0 1
R1911 4 2 1
R1912 1 7 1
R1913 5 3 1
R1914 1 1 1
R1915 2 1 1
R1916 8 8 1
R1917 9 1 1
R1918 9 7 1
R1919 3 0 1
R1920 0 2 1
R1921 1 8 1
R1922 2 7 1
R1923 5 3 1
R1924 5 6 1
R1925 7 7 1
R1926 5 4 1
R1927 8 1 1
R1928 4 9 1
R1929 2 0 1
R1930 9 4 1
R1931 1 5 1
R1932 3 5 1
R1933 0 2 1
R1934 3 9 1
R1935 0 5 1
R1936 6 1 1
R1937 5 0 1
R1938 6 7 1
R1939 6 7 1
R1940 6 9 1
R1941 4 9 1
R1942 9 6 1
R1943 9 9 1
R1944 0 6 1
R1945 8 8 1
R1946 0 9 1
R1947 5 6 1
R1948 6 1 1
R1949 8 4 1
R1950 0 6 1
R1951 6 7 1
R1952 9 4 1
R1953 2 6 1
R1954 0 9 1
R1955 2 7 1
R1956 7 5 1
R1957 9 0 1
R1958 4 6 1
R1959 8 3 1
R1960 1 4 1
R1961 4 4 1
R1962 6 7 1
R1963 5 5 1
R1964 3 2 1
R1965 7 9 1
R1966 5 3 1
R1967 9 7 1
R1968 5 9 1
R1969 0 0 1
R1970 4 9 1
R1971 8 0 1
R1972 8 4 1
R1973 7 3 1
R1974 2 6 1
R1975 8 1 1
R1976 2 0 1
R1977 2 7 1
R1978 5 6 1
R1979 1 8 1
R1980 8 3 1
R1981 8 3 1
R1982 0 6 1
R1983 2 8 1
R1984 5 2 1
R1985 4 9 1
R1986 5 5 1
R1987 5 5 1
R1988 4 5 1
R1989 5 5 1
R1990 5 4 1
R1991 2 3 1
R1992 9 1 1
R1993 6 1 1
R1994 1 8 1
R1995 6 4 1
R1996 7 2 1
R1997 9 0 1
R1998 4 5 1
R1999 7 8 1
R2000 5 9 1
R2001 0 6 1
R2002 1 5 1
R2003 2 6 1
R2004 7 2 1
R2005 5 6 1
R2006 2 2 1
R2007 6 1 1
R2008 0 3 1
R2009 4 2 1
R2010 2 8 1
R2011 3 4 1
R2012 8 1 1
R2013 2 4 1
R2014 4 9 1
R2015 6 1 1
R2016 9 9 1
R2017 7 5 1
R2018 1 7 1
R2019 9 5 1
R2020 6 3 1
R2021 3 5 1
R2022 9 5 1
R2023 9 2 1
R2024 3 8 1
R2025 6 8 1
R2026 3 4 1
R2027 3 2 1
R2028 9 2 1
R2029 4 6 1
R2030 2 4 1
R2031 9 4 1
R2032 7 8 1
R2033 7 0 1
R2034 1 5 1
R2035 1 8 1
R2036 5 3 1
R2037 2 8 1
R2038 5 0 1
R2039 2 5 1
R2040 2 0 1
R2041 3 2 1
R2042 0 0 1
R2043 5 9 1
R2044 7 6 1
R2045 0 5 1
R2046 3 3 1
R2047 7 0 1
R2048 3 8 1
R2049 1 2 1
R2050 4 3 1
R2051 8 5 1
R2052 9 9 1
R2053 0 2 1
R2054 1 8 1
R2055 8 2 1
R2056 3 9 1
R2057 8 6 1
R2058 7 1 1
R2059 8 7 1
R2060 6 4 1
R2061 0 4 1
R2062 3 6 1
R2063 0 4 1
R2064 3 2 1
R2065 4 6 1
R2066 4 7 1
R2067 8 0 1
R2068 4 2 1
R2069 2 8 1
R2070 9 5 1
R2071 6 7 1
R2072 6 9 1
R2073 2 8 1
R2074 0 5 1
R2075 3 7 1
R2076 8 2 1
R2077 6 1 1
R2078 0 5 1
R2079 3 6 1
R2080 8 3 1
R2081 5 5 1
R2082 9 7 1
R2083 0 1 1
R2084 6 3 1
R2085 7 8 1
R2086 1 2 1
R2087 1 0 1
R2088 2 6 1
R2089 9 9 1
R2090 5 0 1
R2091 6 0 1
R2092 1 8 1
R2093 3 4 1
R2094 2 1 1
R2095 5 7 1
R2096 8 7 1
R2097 9 4 1
R2098 8 1 1
R2099 5 6 1
R2100 5 5 1
R2101 0 7 1
R2102 4 9 1
R2103 4 6 1
R2104 1 4 1
R2105 6 1 1
R2106 7 1 1
R2107 2 4 1
R2108 1 8 1
R2109 7 6 1
R2110 4 8 1
R2111 2 0 1
R2112 2 6 1
R2113 0 1 1
R2114 1 0 1
R2115 2 9 1
R2116 3 5 1
R2117 4 6 1
R2118 3 6 1
R2119 1 3 1
R2120 1 7 1
R2121 4 1 1
R2122 7 5 1
R2123 7 4 1
R2124 1 5 1
R2125 7 2 1
R2126 4 6 1
R2127 0 3 1
R2128 5 7 1
R2129 9 2 1
R2130 7 3 1
R2131 6 4 1
R2132 9 8 1
R2133 4 3 1
R2134 8 1 1
R2135 3 3 1
R2136 0 1 1
R2137 0 2 1
R2138 9 3 1
R2139 5 1 1
R2140 2 2 1
R2141 7 1 1
R2142 9 1 1
R2143 2 5 1
R2144 5 4 1
R2145 4 8 1
R2146 2 2 1
R2147 9 9 1
R2148 8 9 1
R2149 7 6 1
R2150 8 7 1
R2151 2 7 1
R2152 0 7 1
R2153 9 2 1
R2154 8 6 1
R2155 1 1 1
R2156 8 4 1
R2157 7 1 1
R2158 2 2 1
R2159 1 8 1
R2160 4 3 1
R2161 2 0 1
R2162 9 5 1
R2163 7 4 1
R2164 8 2 1
R2165 7 8 1
R2166 5 1 1
R2167 9 6 1
R2168 7 4 1
R2169 3 2 1
R2170 6 1 1
R2171 8 6 1
R2172 0 2 1
R2173 6 6 1
R2174 3 6 1
R2175 1 9 1
R2176 0 8 1
R2177 7 2 1
R2178 6 7 1
R2179 5 6 1
R2180 0 9 1
R2181 7 4 1
R2182 1 0 1
R2183 2 4 1
R2184 3 8 1
R2185 1 7 1
R2186 5 1 1
R2187 8 7 1
R2188 6 7 1
R2189 5 6 1
R2190 6 3 1
R2191 0 4 1
R2192 1 6 1
R2193 4 5 1
R2194 1 4 1
R2195 9 6 1
R2196 0 8 1
R2197 4 3 1
R2198 2 7 1
R2199 0 7 1
R2200 5 3 1
R2201 9 0 1
R2202 7 7 1
R2203 7 3 1
R2204 2 8 1
R2205 8 5 1
R2206 9 1 1
R2207 5 8 1
R2208 8 2 1
R2209 6 0 1
R2210 2 4 1
R2211 8 9 1
R2212 0 2 1
R2213 7 0 1
R2214 2 1 1
R2215 0 6 1
R2216 0 8 1
R2217 2 1 1
R2218 0 6 1
R2219 0 5 1
R2220 4 2 1
R2221 5 7 1
R2222 8 2 1
R2223 8 0 1
R2224 7 4 1
R2225 1 9 1
R2226 1 1 1
R2227 7 1 1
R2228 8 8 1
R2229 9 5 1
R2230 1 0 1
R2231 0 5 1
R2232 0 7 1
R2233 2 6 1
R2234 8 2 1
R2235 3 2 1
R2236 6 4 1
R2237 1 8 1
R2238 9 1 1
R2239 4 0 1
R2240 8 0 1
R2241 4 9 1
R2242 1 4 1
R2243 3 0 1
R2244 4 8 1
R2245 9 8 1
R2246 7 0 1
R2247 5 8 1
R2248 4 8 1
R2249 0 4 1
R2250 1 9 1
R2251 7 0 1
R2252 4 2 1
R2253 0 2 1
R2254 4 1 1
R2255 6 5 1
R2256 9 4 1
R2257 1 1 1
R2258 5 2 1
R2259 1 3 1
R2260 5 4 1
R2261 8 4 1
R2262 3 9 1
R2263 7 3 1
R2264 6 9 1
R2265 7 4 1
R2266 0 3 1
R2267 4 1 1
R2268 5 0 1
R2269 9 3 1
R2270 4 2 1
R2271 3 0 1
R2272 8 5 1
R2273 9 5 1
R2274 9 9 1
R2275 7 3 1
R2276 3 6 1
R2277 5 0 1
R2278 7 4 1
R2279 5 1 1
R2280 8 7 1
R2281 2 0 1
R2282 3 9 1
R2283 6 0 1
R2284 3 5 1
R2285 7 2 1
R2286 3 4 1
R2287 0 6 1
R2288 3 1 1
R2289 0 7 1
R2290 2 7 1
R2291 0 8 1
R2292 9 5 1
R2293 5 4 1
R2294 6 5 1
R2295 7 7 1
R2296 8 9 1
R2297 4 1 1
R2298 7 2 1
R2299 5 4 1
R2300 3 5 1
R2301 9 6 1
R2302 7 9 1
R2303 5 5 1
R2304 4 0 1
R2305 9 6 1
R2306 0 4 1
R2307 5 1 1
R2308 2 7 1
R2309 8 9 1
R2310 5 6 1
R2311 0 7 1
R2312 0 5 1
R2313 1 2 1
R2314 5 0 1
R2315 5 3 1
R2316 2 6 1
R2317 6 2 1
R2318 8 6 1
R2319 7 3 1
R2320 7 1 1
R2321 7 2 1
R2322 5 5 1
R2323 3 3 1
R2324 2 8 1
R2325 9 0 1
R2326 0 2 1
R2327 9 1 1
R2328 7 5 1
R2329 8 9 1
R2330 2 9 1
R2331 9 0 1
R2332 2 5 1
R2333 8 4 1
R2334 6 9 1
R2335 2 9 1
R2336 0 9 1
R2337 5 7 1
R2338 9 3 1
R2339 2 3 1
R2340 3 5 1
R2341 1 3 1
R2342 1 8 1
R2343 0 3 1
R2344 7 3 1
R2345 4 5 1
R2346 7 5 1
R2347 0 2 1
R2348 1 0 1
R2349 4 4 1
R2350 1 8 1
R2351 0 6 1
R2352 4 0 1
R2353 4 9 1
R2354 4 6 1
R2355 6 9 1
R2356 7 9 1
R2357 9 5 1
R2358 9 6 1
R2359 7 4 1
R2360 1 2 1
R2361 2 9 1
R2362 0 5 1
R2363 9 3 1
R2364 1 9 1
R2365 4 1 1
R2366 5 6 1
R2367 6 4 1
R2368 3 6 1
R2369 6 7 1
R2370 9 4 1
R2371 9 3 1
R2372 2 4 1
R2373 8 3 1
R2374 1 2 1
R2375 1 6 1
R2376 4 9 1
R2377 4 9 1
R2378 2 7 1
R2379 8 8 1
R2380 0 1 1
R2381 1 4 1
R2382 8 4 1
R2383 5 2 1
R2384 4 2 1
R2385 6 3 1
R2386 6 7 1
R2387 9 2 1
R2388 3 4 1
R2389 5 5 1
R2390 7 1 1
R2391 8 7 1
R2392 2 6 1
R2393 8 0 1
R2394 2 7 1
R2395 4 0 1
R2396 9 3 1
R2397 9 7 1
R2398 5 6 1
R2399 0 1 1
R2400 0 6 1
R2401 2 2 1
R2402 6 5 1
R2403 5 3 1
R2404 9 3 1
R2405 7 4 1
R2406 8 1 1
R2407 7 2 1
R2408 9 3 1
R2409 2 9 1
R2410 8 6 1
R2411 8 7 1
R2412 8 5 1
R2413 5 5 1
R2414 2 8 1
R2415 0 3 1
R2416 4 8 1
R2417 1 1 1
R2418 0 7 1
R2419 0 7 1
R2420 2 3 1
R2421 0 7 1
R2422 0 2 1
R2423 9 7 1
R2424 5 0 1
R2425 0 4 1
R2426 5 9 1
R2427 5 6 1
R2428 2 9 1
R2429 2 5 1
R2430 7 8 1
R2431 9 1 1
R2432 1 0 1
R2433 1 8 1
R2434 6 8 1
R2435 2 6 1
R2436 3 8 1
R2437 5 2 1
R2438 3 6 1
R2439 3 3 1
R2440 0 8 1
R2441 9 7 1
R2442 7 8 1
R2443 4 1 1
R2444 5 9 1
R2445 8 9 1
R2446 6 2 1
R2447 5 6 1
R2448 5 9 1
R2449 3 2 1
R2450 7 6 1
R2451 8 9 1
R2452 6 6 1
R2453 1 5 1
R2454 5 4 1
R2455 8 9 1
R2456 5 7 1
R2457 1 3 1
R2458 6 9 1
R2459 9 7 1
R2460 8 0 1
R2461 8 2 1
R2462 3 4 1
R2463 5 6 1
R2464 9 0 1
R2465 4 4 1
R2466 0 3 1
R2467 0 2 1
R2468 3 9 1
R2469 3 7 1
R2470 6 7 1
R2471 1 1 1
R2472 0 9 1
R2473 5 7 1
R2474 2 1 1
R2475 7 3 1
R2476 1 8 1
R2477 2 1 1
R2478 6 8 1
R2479 1 8 1
R2480 6 5 1
R2481 4 4 1
R2482 0 2 1
R2483 2 9 1
R2484 4 7 1
R2485 8 1 1
R2486 2 9 1
R2487 7 8 1
R2488 4 5 1
R2489 3 4 1
R2490 5 6 1
R2491 8 7 1
R2492 3 7 1
R2493 5 4 1
R2494 3 0 1
R2495 8 7 1
R2496 2 4 1
R2497 7 5 1
R2498 4 5 1
R2499 0 4 1
R2500 5 0 1
R2501 3 4 1
R2502 7 0 1
R2503 5 1 1
R2504 1 9 1
R2505 9 1 1
R2506 0 4 1
R2507 1 8 1
R2508 8 6 1
R2509 3 6 1
R2510 5 4 1
R2511 9 3 1
R2512 8 9 1
R2513 4 0 1
R2514 2 4 1
R2515 0 8 1
R2516 7 7 1
R2517 1 4 1
R2518 4 6 1
R2519 9 1 1
R2520 8 0 1
R2521 5 0 1
R2522 1 3 1
R2523 2 6 1
R2524 5 7 1
R2525 7 0 1
R2526 0 4 1
R2527 5 6 1
R2528 0 3 1
R2529 5 7 1
R2530 5 2 1
R2531 5 5 1
R2532 0 3 1
R2533 8 3 1
R2534 1 4 1
R2535 0 4 1
R2536 3 5 1
R2537 3 5 1
R2538 5 4 1
R2539 6 6 1
R2540 2 1 1
R2541 4 6 1
R2542 7 9 1
R2543 7 5 1
R2544 8 0 1
R2545 7 5 1
R2546 5 1 1
R2547 9 3 1
R2548 9 6 1
R2549 3 7 1
R2550 9 4 1
R2551 4 0 1
R2552 2 3 1
R2553 0 9 1
R2554 1 8 1
R2555 0 7 1
R2556 4 0 1
R2557 3 3 1
R2558 4 8 1
R2559 7 5 1
R2560 6 2 1
R2561 3 8 1
R2562 4 6 1
R2563 3 7 1
R2564 7 2 1
R2565 0 0 1
R2566 7 4 1
R2567 3 4 1
R2568 0 0 1
R2569 9 7 1
R2570 5 7 1
R2571 5 5 1
R2572 7 4 1
R2573 9 5 1
R2574 4 7 1
R2575 0 7 1
R2576 1 2 1
R2577 4 3 1
R2578 0 1 1
R2579 0 6 1
R2580 8 8 1
R2581 0 4 1
R2582 5 1 1
R2583 4 3 1
R2584 7 8 1
R2585 9 5 1
R2586 3 1 1
R2587 0 7 1
R2588 1 8 1
R2589 5 9 1
R2590 9 4 1
R2591 6 5 1
R2592 1 3 1
R2593 3 5 1
R2594 9 0 1
R2595 8 2 1
R2596 2 4 1
R2597 1 3 1
R2598 1 6 1
R2599 2 2 1
R2600 4 1 1
R2601 4 4 1
R2602 3 4 1
R2603 3 6 1
R2604 8 6 1
R2605 0 6 1
R2606 4 0 1
R2607 2 5 1
R2608 9 1 1
R2609 7 8 1
R2610 9 6 1
R2611 9 8 1
R2612 9 4 1
R2613 4 1 1
R2614 8 9 1
R2615 3 5 1
R2616 1 4 1
R2617 3 7 1
R2618 5 3 1
R2619 5 0 1
R2620 0 5 1
R2621 6 6 1
R2622 3 1 1
R2623 6 7 1
R2624 4 8 1
R2625 1 5 1
R2626 0 3 1
R2627 9 1 1
R2628 5 9 1
R2629 6 8 1
R2630 3 0 1
R2631 5 0 1
R2632 5 2 1
R2633 3 8 1
R2634 0 8 1
R2635 9 2 1
R2636 1 5 1
R2637 4 4 1
R2638 7 5 1
R2639 9 1 1
R2640 8 1 1
R2641 9 4 1
R2642 5 1 1
R2643 6 3 1
R2644 7 7 1
R2645 5 5 1
R2646 2 6 1
R2647 9 1 1
R2648 6 6 1
R2649 5 5 1
R2650 8 5 1
R2651 2 5 1
R2652 3 8 1
R2653 5 8 1
R2654 2 7 1
R2655 0 1 1
R2656 3 6 1
R2657 0 4 1
R2658 6 7 1
R2659 7 7 1
R2660 6 4 1
R2661 6 5 1
R2662 0 1 1
R2663 7 6 1
R2664 4 6 1
R2665 4 3 1
R2666 4 1 1
R2667 3 7 1
R2668 9 5 1
R2669 2 1 1
R2670 9 1 1
R2671 9 1 1
R2672 7 5 1
R2673 0 6 1
R2674 8 6 1
R2675 8 8 1
R2676 0 5 1
R2677 3 7 1
R2678 3 3 1
R2679 6 5 1
R2680 7 5 1
R2681 8 1 1
R2682 4 5 1
R2683 3 7 1
R2684 3 2 1
R2685 4 4 1
R2686 2 9 1
R2687 9 3 1
R2688 2 4 1
R2689 7 8 1
R2690 0 7 1
R2691 2 2 1
R2692 2 4 1
R2693 3 9 1
R2694 7 6 1
R2695 9 8 1
R2696 5 9 1
R2697 0 8 1
R2698 9 7 1
R2699 3 4 1
R2700 9 5 1
R2701 0 3 1
R2702 3 4 1
R2703 2 5 1
R2704 3 0 1
R2705 2 9 1
R2706 4 0 1
R2707 5 5 1
R2708 4 2 1
R2709 6 6 1
R2710 6 7 1
R2711 3 3 1
R2712 7 4 1
R2713 4 5 1
R2714 1 3 1
R2715 4 0 1
R2716 3 7 1
R2717 5 9 1
R2718 8 4 1
R2719 7 3 1
R2720 9 0 1
R2721 2 6 1
R2722 4 7 1
R2723 9 8 1
R2724 2 1 1
R2725 9 0 1
R2726 6 3 1
R2727 7 8 1
R2728 9 7 1
R2729 7 2 1
R2730 5 7 1
R2731 7 7 1
R2732 3 4 1
R2733 1 1 1
R2734 5 6 1
R2735 6 3 1
R2736 4 0 1
R2737 9 7 1
R2738 1 2 1
R2739 5 0 1
R2740 2 9 1
R2741 9 1 1
R2742 5 0 1
R2743 4 2 1
R2744 3 4 1
R2745 9 5 1
R2746 9 2 1
R2747 8 0 1
R2748 3 2 1
R2749 9 7 1
R2750 0 4 1
R2751 8 7 1
R2752 9 6 1
R2753 5 5 1
R2754 6 7 1
R2755 4 8 1
R2756 4 9 1
R2757 7 3 1
R2758 1 6 1
R2759 5 2 1
R2760 6 3 1
R2761 1 5 1
R2762 0 3 1
R2763 0 8 1
R2764 9 6 1
R2765 6 2 1
R2766 5 4 1
R2767 8 4 1
R2768 6 6 1
R2769 1 3 1
R2770 5 1 1
R2771 8 8 1
R2772 4 9 1
R2773 6 5 1
R2774 7 1 1
R2775 0 5 1
R2776 6 0 1
R2777 4 7 1
R2778 0 9 1
R2779 4 4 1
R2780 7 1 1
R2781 7 9 1
R2782 1 5 1
R2783 3 5 1
R2784 7 7 1
R2785 7 9 1
R2786 1 0 1
R2787 3 2 1
R2788 9 4 1
R2789 2 7 1
R2790 3 6 1
R2791 6 3 1
R2792 0 4 1
R2793 7 0 1
R2794 0 9 1
R2795 1 2 1
R2796 0 5 1
R2797 2 8 1
R2798 0 3 1
R2799 0 5 1
R2800 2 7 1
R2801 0 2 1
R2802 4 6 1
R2803 8 2 1
R2804 5 2 1
R2805 2 5 1
R2806 5 8 1
R2807 4 8 1
R2808 3 0 1
R2809 1 6 1
R2810 2 7 1
R2811 2 8 1
R2812 6 6 1
R2813 9 5 1
R2814 0 6 1
R2815 6 2 1
R2816 7 4 1
R2817 3 8 1
R2818 0 5 1
R2819 1 7 1
R2820 2 7 1
R2821 4 6 1
R2822 7 8 1
R2823 5 9 1
R2824 3 0 1
R2825 4 9 1
R2826 0 1 1
R2827 4 4 1
R2828 0 0 1
R2829 4 1 1
R2830 3 5 1
R2831 1 6 1
R2832 6 5 1
R2833 9 0 1
R2834 1 4 1
R2835 9 9 1
R2836 2 2 1
R2837 4 3 1
R2838 7 9 1
R2839 2 5 1
R2840 5 2 1
R2841 9 7 1
R2842 2 3 1
R2843 0 8 1
R2844 5 3 1
R2845 7 7 1
R2846 9 1 1
R2847 0 4 1
R2848 6 1 1
R2849 5 7 1
R2850 1 7 1
R2851 5 8 1
R2852 4 7 1
R2853 5 4 1
R2854 3 0 1
R2855 6 9 1
R2856 5 2 1
R2857 2 8 1
R2858 6 5 1
R2859 2 0 1
R2860 8 3 1
R2861 1 6 1
R2862 8 7 1
R2863 3 7 1
R2864 9 2 1
R2865 8 9 1
R2866 0 0 1
R2867 6 3 1
R2868 7 8 1
R2869 4 8 1
R2870 5 0 1
R2871 2 3 1
R2872 0 3 1
R2873 3 6 1
R2874 8 0 1
R2875 1 8 1
R2876 4 0 1
R2877 4 7 1
R2878 2 4 1
R2879 6 7 1
R2880 0 4 1
R2881 3 3 1
R2882 4 0 1
R2883 1 2 1
R2884 2 5 1
R2885 0 2 1
R2886 6 6 1
R2887 4 1 1
R2888 8 0 1
R2889 1 6 1
R2890 4 7 1
R2891 7 4 1
R2892 3 0 1
R2893 1 0 1
R2894 0 5 1
R2895 4 7 1
R2896 4 8 1
R2897 1 1 1
R2898 1 4 1
R2899 7 6 1
R2900 0 3 1
R2901 0 0 1
R2902 7 3 1
R2903 3 7 1
R2904 1 7 1
R2905 1 9 1
R2906 3 5 1
R2907 9 8 1
R2908 6 5 1
R2909 1 5 1
R2910 8 5 1
R2911 8 0 1
R2912 3 4 1
R2913 6 2 1
R2914 0 6 1
R2915 3 0 1
R2916 7 7 1
R2917 0 2 1
R2918 4 9 1
R2919 1 9 1
R2920 7 2 1
R2921 7 2 1
R2922 9 0 1
R2923 9 9 1
R2924 4 9 1
R2925 7 1 1
R2926 1 3 1
R2927 7 2 1
R2928 5 2 1
R2929 9 7 1
R2930 7 0 1
R2931 3 6 1
R2932 6 9 1
R2933 2 9 1
R2934 6 4 1
R2935 7 3 1
R2936 0 7 1
R2937 5 3 1
R2938 8 0 1
R2939 1 8 1
R2940 3 5 1
R2941 6 3 1
R2942 8 4 1
R2943 0 8 1
R2944 2 6 1
R2945 3 3 1
R2946 8 5 1
R2947 0 5 1
R2948 7 3 1
R2949 8 8 1
R2950 7 7 1
R2951 3 7 1
R2952 8 1 1
R2953 0 3 1
R2954 0 6 1
R2955 3 8 1
R2956 6 2 1
R2957 9 5 1
R2958 5 2 1
R2959 9 5 1
R2960 6 1 1
R2961 3 8 1
R2962 3 5 1
R2963 0 6 1
R2964 4 6 1
R2965 1 4 1
R2966 9 6 1
R2967 5 3 1
R2968 3 6 1
R2969 0 8 1
R2970 9 3 1
R2971 0 1 1
R2972 9 0 1
R2973 3 2 1
R2974 6 1 1
R2975 3 5 1
R2976 2 2 1
R2977 2 0 1
R2978 6 0 1
R2979 7 6 1
R2980 9 2 1
R2981 3 0 1
R2982 2 7 1
R2983 1 7 1
R2984 6 4 1
R2985 4 7 1
R2986 7 6 1
R2987 0 5 1
R2988 2 7 1
R2989 8 7 1
R2990 9 7 1
R2991 5 3 1
R2992 6 9 1
R2993 7 6 1
R2994 5 2 1
R2995 8 1 1
R2996 4 7 1
R2997 0 8 1
R2998 8 3 1
R2999 0 6 1
R3000 5 4 1
R3001 6 7 1
R3002 6 9 1
R3003 1 5 1
R3004 3 6 1
R3005 3 2 1
R3006 0 9 1
R3007 0 3 1
R3008 8 6 1
R3009 5 3 1
R3010 6 0 1
R3011 8 9 1
R3012 1 6 1
R3013 4 4 1
R3014 4 8 1
R3015 4 3 1
R3016 4 2 1
R3017 6 2 1
R3018 0 6 1
R3019 3 2 1
R3020 7 9 1
R3021 0 0 1
R3022 4 0 1
R3023 9 6 1
R3024 4 3 1
R3025 2 0 1
R3026 0 3 1
R3027 5 5 1
R3028 6 5 1
R3029 4 7 1
R3030 4 4 1
R3031 1 5 1
R3032 9 5 1
R3033 9 9 1
R3034 6 3 1
R3035 1 3 1
R3036 2 2 1
R3037 8 5 1
R3038 5 8 1
R3039 7 3 1
R3040 6 3 1
R3041 1 5 1
R3042 5 9 1
R3043 1 4 1
R3044 6 0 1
R3045 8 8 1
R3046 3 0 1
R3047 0 4 1
R3048 0 2 1
R3049 8 6 1
R3050 6 4 1
R3051 2 6 1
R3052 7 3 1
R3053 3 6 1
R3054 4 3 1
R3055 9 2 1
R3056 6 0 1
R3057 9 1 1
R3058 4 4 1
R3059 9 3 1
R3060 7 8 1
R3061 5 3 1
R3062 6 7 1
R3063 1 6 1
R3064 1 2 1
R3065 9 4 1
R3066 9 9 1
R3067 9 5 1
R3068 4 7 1
R3069 7 4 1
R3070 9 9 1
R3071 0 6 1
R3072 0 6 1
R3073 7 7 1
R3074 5 8 1
R3075 1 4 1
R3076 8 4 1
R3077 3 9 1
R3078 7 1 1
R3079 1 6 1
R3080 8 9 1
R3081 2 8 1
R3082 8 0 1
R3083 1 6 1
R3084 4 1 1
R3085 0 3 1
R3086 3 4 1
R3087 7 0 1
R3088 2 4 1
R3089 0 3 1
R3090 7 6 1
R3091 0 1 1
R3092 0 1 1
R3093 3 5 1
R3094 2 0 1
R3095 1 5 1
R3096 1 5 1
R3097 2 4 1
R3098 9 4 1
R3099 8 2 1
R3100 3 7 1
R3101 3 8 1
R3102 8 1 1
R3103 0 4 1
R3104 8 7 1
R3105 5 3 1
R3106 3 3 1
R3107 5 2 1
R3108 9 1 1
R3109 4 5 1
R3110 3 8 1
R3111 3 2 1
R3112 2 6 1
R3113 9 5 1
R3114 0 8 1
R3115 0 8 1
R3116 7 5 1
R3117 8 0 1
R3118 7 1 1
R3119 2 8 1
R3120 9 1 1
R3121 7 2 1
R3122 7 5 1
R3123 5 1 1
R3124 3 2 1
R3125 9 6 1
R3126 8 9 1
R3127 5 7 1
R3128 0 7 1
R3129 0 0 1
R3130 4 0 1
R3131 4 5 1
R3132 3 1 1
R3133 7 9 1
R3134 8 6 1
R3135 4 0 1
R3136 5 0 1
R3137 3 1 1
R3138 2 4 1
R3139 7 6 1
R3140 5 6 1
R3141 1 3 1
R3142 0 4 1
R3143 6 2 1
R3144 9 9 1
R3145 6 5 1
R3146 2 6 1
R3147 6 2 1
R3148 8 4 1
R3149 4 1 1
R3150 8 0 1
R3151 7 8 1
R3152 3 7 1
R3153 2 0 1
R3154 6 8 1
R3155 2 0 1
R3156 4 7 1
R3157 9 0 1
R3158 8 4 1
R3159 2 5 1
R3160 5 1 1
R3161 6 1 1
R3162 8 5 1
R3163 7 5 1
R3164 6 4 1
R3165 0 6 1
R3166 3 4 1
R3167 8 2 1
R3168 4 0 1
R3169 2 6 1
R3170 7 6 1
R3171 5 4 1
R3172 4 8 1
R3173 0 2 1
R3174 2 1 1
R3175 0 2 1
R3176 4 5 1
R3177 7 6 1
R3178 9 3 1
R3179 6 8 1
R3180 4 1 1
R3181 8 3 1
R3182 0 2 1
R3183 8 8 1
R3184 9 3 1
R3185 8 4 1
R3186 6 2 1
R3187 2 1 1
R3188 4 5 1
R3189 0 4 1
R3190 5 3 1
R3191 5 7 1
R3192 6 8 1
R3193 5 7 1
R3194 5 2 1
R3195 0 3 1
R3196 0 7 1
R3197 3 4 1
R3198 5 8 1
R3199 2 4 1
R3200 3 0 1
R3201 9 9 1
R3202 1 4 1
R3203 6 3 1
R3204 8 0 1
R3205 0 6 1
R3206 1 3 1
R3207 2 4 1
R3208 7 6 1
R3209 3 9 1
R3210 6 7 1
R3211 6 2 1
R3212 8 2 1
R3213 8 7 1
R3214 6 5 1
R3215 8 6 1
R3216 6 8 1
R3217 6 7 1
R3218 0 5 1
R3219 2 1 1
R3220 6 1 1
R3221 6 2 1
R3222 0 1 1
R3223 4 7 1
R3224 3 3 1
R3225 7 2 1
R3226 8 8 1
R3227 9 0 1
R3228 4 9 1
R3229 9 3 1
R3230 7 7 1
R3231 1 7 1
R3232 7 4 1
R3233 6 2 1
R3234 3 7 1
R3235 1 7 1
R3236 4 7 1
R3237 8 7 1
R3238 2 9 1
R3239 4 8 1
R3240 3 6 1
R3241 0 7 1
R3242 7 5 1
R3243 4 4 1
R3244 6 1 1
R3245 4 9 1
R3246 4 5 1
R3247 8 0 1
R3248 7 2 1
R3249 8 6 1
R3250 0 9 1
R3251 8 2 1
R3252 8 9 1
R3253 9 8 1
R3254 3 0 1
R3255 3 0 1
R3256 3 5 1
R3257 6 3 1
R3258 9 7 1
R3259 7 6 1
R3260 4 5 1
R3261 6 1 1
R3262 6 1 1
R3263 6 2 1
R3264 0 2 1
R3265 9 5 1
R3266 2 7 1
R3267 0 1 1
R3268 8 1 1
R3269 2 8 1
R3270 2 4 1
R3271 2 0 1
R3272 9 4 1
R3273 4 4 1
R3274 3 2 1
R3275 9 8 1
R3276 0 7 1
R3277 5 9 1
R3278 2 3 1
R3279 5 1 1
R3280 9 0 1
R3281 5 1 1
R3282 7 1 1
R3283 2 0 1
R3284 2 1 1
R3285 1 9 1
R3286 1 4 1
R3287 1 3 1
R3288 9 9 1
R3289 7 2 1
R3290 5 5 1
R3291 1 2 1
R3292 8 3 1
R3293 0 2 1
R3294 6 0 1
R3295 3 2 1
R3296 0 3 1
R3297 1 3 1
R3298 8 6 1
R3299 9 2 1
R3300 5 9 1
R3301 8 9 1
R3302 1 6 1
R3303 7 1 1
R3304 1 1 1
R3305 2 3 1
R3306 2 2 1
R3307 6 1 1
R3308 1 8 1
R3309 8 5 1
R3310 9 6 1
R3311 4 7 1
R3312 9 9 1
R3313 2 8 1
R3314 3 2 1
R3315 0 7 1
R3316 3 0 1
R3317 0 8 1
R3318 9 0 1
R3319 1 8 1
R3320 7 5 1
R3321 2 9 1
R3322 5 5 1
R3323 3 9 1
R3324 5 4 1
R3325 8 9 1
R3326 7 8 1
R3327 2 7 1
R3328 0 6 1
R3329 7 5 1
R3330 9 4 1
R3331 3 6 1
R3332 7 4 1
R3333 3 6 1
R3334 7 1 1
R3335 8 3 1
R3336 7 1 1
R3337 9 4 1
R3338 6 5 1
R3339 1 2 1
R3340 7 1 1
R3341 3 9 1
R3342 6 2 1
R3343 2 9 1
R3344 8 3 1
R3345 7 2 1
R3346 0 6 1
R3347 3 2 1
R3348 8 3 1
R3349 4 1 1
R3350 3 3 1
R3351 5 3 1
R3352 7 7 1
R3353 4 8 1
R3354 7 4 1
R3355 1 9 1
R3356 8 0 1
R3357 3 1 1
R3358 4 4 1
R3359 8 9 1
R3360 7 7 1
R3361 3 3 1
R3362 6 4 1
R3363 7 1 1
R3364 6 0 1
R3365 8 9 1
R3366 5 8 1
R3367 3 3 1
R3368 2 3 1
R3369 1 3 1
R3370 0 3 1
R3371 5 7 1
R3372 6 1 1
R3373 9 1 1
R3374 9 9 1
R3375 9 2 1
R3376 2 0 1
R3377 4 7 1
R3378 1 7 1
R3379 8 6 1
R3380 9 7 1
R3381 8 2 1
R3382 5 3 1
R3383 3 5 1
R3384 8 6 1
R3385 6 3 1
R3386 7 6 1
R3387 6 2 1
R3388 9 8 1
R3389 5 8 1
R3390 3 7 1
R3391 0 8 1
R3392 6 0 1
R3393 1 1 1
R3394 2 5 1
R3395 9 6 1
R3396 0 9 1
R3397 7 2 1
R3398 4 2 1
R3399 2 9 1
R3400 4 7 1
R3401 0 4 1
R3402 9 3 1
R3403 2 9 1
R3404 4 0 1
R3405 4 1 1
R3406 9 6 1
R3407 8 0 1
R3408 7 4 1
R3409 1 6 1
R3410 1 2 1
R3411 3 7 1
R3412 6 7 1
R3413 6 6 1
R3414 5 9 1
R3415 5 3 1
R3416 1 6 1
R3417 2 0 1
R3418 7 7 1
R3419 5 9 1
R3420 2 6 1
R3421 8 3 1
R3422 1 2 1
R3423 6 9 1
R3424 5 6 1
R3425 8 0 1
R3426 7 1 1
R3427 1 6 1
R3428 7 0 1
R3429 0 7 1
R3430 4 3 1
R3431 4 5 1
R3432 9 3 1
R3433 8 9 1
R3434 5 2 1
R3435 2 0 1
R3436 5 6 1
R3437 6 8 1
R3438 4 0 1
R3439 7 7 1
R3440 4 4 1
R3441 9 7 1
R3442 5 9 1
R3443 7 6 1
R3444 4 6 1
R3445 5 0 1
R3446 4 4 1
R3447 0 9 1
R3448 4 8 1
R3449 2 6 1
R3450 2 2 1
R3451 2 0 1
R3452 6 8 1
R3453 1 6 1
R3454 5 5 1
R3455 4 1 1
R3456 4 0 1
R3457 5 9 1
R3458 1 3 1
R3459 6 9 1
R3460 5 1 1
R3461 2 5 1
R3462 7 1 1
R3463 8 5 1
R3464 7 0 1
R3465 5 8 1
R3466 2 8 1
R3467 9 4 1
R3468 3 4 1
R3469 7 9 1
R3470 4 1 1
R3471 9 6 1
R3472 0 3 1
R3473 9 0 1
R3474 1 6 1
R3475 9 1 1
R3476 0 3 1
R3477 8 9 1
R3478 1 2 1
R3479 1 3 1
R3480 5 5 1
R3481 5 6 1
R3482 3 8 1
R3483 1 7 1
R3484 8 1 1
R3485 4 9 1
R3486 9 8 1
R3487 1 6 1
R3488 3 6 1
R3489 0 4 1
R3490 7 9 1
R3491 3 1 1
R3492 7 2 1
R3493 4 0 1
R3494 6 1 1
R3495 4 1 1
R3496 0 9 1
R3497 1 0 1
R3498 7 0 1
R3499 3 6 1
R3500 5 1 1
R3501 1 4 1
R3502 4 6 1
R3503 0 1 1
R3504 5 9 1
R3505 1 3 1
R3506 7 7 1
R3507 7 2 1
R3508 6 8 1
R3509 1 2 1
R3510 8 7 1
R3511 5 4 1
R3512 5 7 1
R3513 9 6 1
R3514 7 5 1
R3515 9 2 1
R3516 8 4 1
R3517 2 6 1
R3518 3 6 1
R3519 6 4 1
R3520 5 6 1
R3521 5 3 1
R3522 8 5 1
R3523 2 9 1
R3524 5 5 1
R3525 8 5 1
R3526 8 6 1
R3527 9 5 1
R3528 8 9 1
R3529 7 1 1
R3530 3 3 1
R3531 0 9 1
R3532 1 9 1
R3533 2 1 1
R3534 1 3 1
R3535 6 9 1
R3536 1 7 1
R3537 4 4 1
R3538 7 4 1
R3539 9 0 1
R3540 4 8 1
R3541 0 2 1
R3542 2 5 1
R3543 0 5 1
R3544 5 8 1
R3545 0 0 1
R3546 2 1 1
R3547 8 1 1
R3548 7 0 1
R3549 6 1 1
R3550 2 3 1
R3551 5 2 1
R3552 7 7 1
R3553 5 3 1
R3554 0 0 1
R3555 7 4 1
R3556 4 4 1
R3557 8 9 1
R3558 7 4 1
R3559 3 2 1
R3560 4 9 1
R3561 3 1 1
R3562 0 7 1
R3563 7 3 1
R3564 2 6 1
R3565 3 1 1
R3566 4 2 1
R3567 3 1 1
R3568 3 6 1
R3569 1 7 1
R3570 4 1 1
R3571 1 4 1
R3572 7 9 1
R3573 7 8 1
R3574 6 9 1
R3575 2 4 1
R3576 9 3 1
R3577 0 5 1
R3578 8 3 1
R3579 3 2 1
R3580 9 3 1
R3581 2 2 1
R3582 1 4 1
R3583 0 3 1
R3584 5 8 1
R3585 5 9 1
R3586 5 7 1
R3587 5 8 1
R3588 6 1 1
R3589 7 0 1
R3590 5 1 1
R3591 6 2 1
R3592 8 2 1
R3593 1 7 1
R3594 0 6 1
R3595 0 4 1
R3596 9 7 1
R3597 8 9 1
R3598 1 8 1
R3599 3 2 1
R3600 5 6 1
R3601 0 7 1
R3602 9 3 1
R3603 8 3 1
R3604 2 7 1
R3605 9 0 1
R3606 8 4 1
R3607 8 1 1
R3608 9 8 1
R3609 1 5 1
R3610 2 4 1
R3611 3 0 1
R3612 6 5 1
R3613 6 6 1
R3614 6 8 1
R3615 2 7 1
R3616 4 5 1
R3617 7 9 1
R3618 2 3 1
R3619 1 1 1
R3620 5 5 1
R3621 6 4 1
R3622 7 4 1
R3623 5 2 1
R3624 7 1 1
R3625 0 8 1
R3626 3 0 1
R3627 9 7 1
R3628 8 9 1
R3629 3 5 1
R3630 4 4 1
R3631 4 5 1
R3632 6 9 1
R3633 7 6 1
R3634 4 3 1
R3635 3 7 1
R3636 3 1 1
R3637 1 9 1
R3638 0 6 1
R3639 2 7 1
R3640 6 2 1
R3641 7 9 1
R3642 0 8 1
R3643 5 9 1
R3644 1 0 1
R3645 9 7 1
R3646 7 9 1
R3647 5 9 1
R3648 6 0 1
R3649 9 1 1
R3650 3 3 1
R3651 3 8 1
R3652 8 4 1
R3653 7 0 1
R3654 2 2 1
R3655 1 8 1
R3656 6 4 1
R3657 3 2 1
R3658 9 8 1
R3659 9 3 1
R3660 3 4 1
R3661 9 7 1
R3662 5 2 1
R3663 1 5 1
R3664 3 5 1
R3665 0 3 1
R3666 2 5 1
R3667 8 6 1
R3668 8 6 1
R3669 0 1 1
R3670 0 8 1
R3671 5 5 1
R3672 9 4 1
R3673 5 8 1
R3674 5 3 1
R3675 2 8 1
R3676 7 1 1
R3677 2 4 1
R3678 6 1 1
R3679 4 3 1
R3680 3 0 1
R3681 2 8 1
R3682 3 8 1
R3683 3 9 1
R3684 4 9 1
R3685 5 4 1
R3686 6 9 1
R3687 4 8 1
R3688 3 6 1
R3689 8 6 1
R3690 0 7 1
R3691 9 6 1
R3692 1 8 1
R3693 1 8 1
R3694 3 6 1
R3695 8 9 1
R3696 6 7 1
R3697 8 4 1
R3698 1 3 1
R3699 8 8 1
R3700 4 8 1
R3701 8 8 1
R3702 1 3 1
R3703 0 9 1
R3704 4 5 1
R3705 1 0 1
R3706 2 0 1
R3707 3 9 1
R3708 2 9 1
R3709 5 1 1
R3710 4 2 1
R3711 8 1 1
R3712 4 6 1
R3713 3 3 1
R3714 5 1 1
R3715 2 8 1
R3716 0 9 1
R3717 0 4 1
R3718 9 3 1
R3719 0 1 1
R3720 4 7 1
R3721 9 8 1
R3722 5 2 1
R3723 5 8 1
R3724 4 8 1
R3725 1 1 1
R3726 7 1 1
R3727 1 5 1
R3728 1 6 1
R3729 4 3 1
R3730 9 0 1
R3731 4 4 1
R3732 6 3 1
R3733 1 3 1
R3734 2 9 1
R3735 5 5 1
R3736 2 0 1
R3737 4 1 1
R3738 1 0 1
R3739 5 3 1
R3740 4 0 1
R3741 0 6 1
R3742 4 9 1
R3743 3 4 1
R3744 0 0 1
R3745 6 6 1
R3746 7 8 1
R3747 3 7 1
R3748 6 0 1
R3749 6 0 1
R3750 8 3 1
R3751 0 6 1
R3752 5 7 1
R3753 3 8 1
R3754 8 3 1
R3755 4 6 1
R3756 8 1 1
R3757 8 8 1
R3758 5 8 1
R3759 9 1 1
R3760 9 2 1
R3761 8 6 1
R3762 6 2 1
R3763 2 5 1
R3764 8 2 1
R3765 2 3 1
R3766 3 6 1
R3767 6 8 1
R3768 3 8 1
R3769 5 6 1
R3770 8 3 1
R3771 0 1 1
R3772 1 3 1
R3773 8 2 1
R3774 5 3 1
R3775 9 3 1
R3776 2 8 1
R3777 3 7 1
R3778 9 6 1
R3779 2 8 1
R3780 0 6 1
R3781 6 4 1
R3782 0 4 1
R3783 3 0 1
R3784 5 9 1
R3785 3 3 1
R3786 5 6 1
R3787 4 1 1
R3788 9 7 1
R3789 8 5 1
R3790 7 0 1
R3791 1 8 1
R3792 3 6 1
R3793 5 3 1
R3794 2 2 1
R3795 4 7 1
R3796 0 6 1
R3797 9 6 1
R3798 3 4 1
R3799 9 5 1
R3800 5 6 1
R3801 6 9 1
R3802 5 5 1
R3803 8 2 1
R3804 9 4 1
R3805 2 8 1
R3806 1 5 1
R3807 3 0 1
R3808 0 3 1
R3809 3 3 1
R3810 0 3 1
R3811 5 1 1
R3812 2 1 1
R3813 1 8 1
R3814 1 4 1
R3815 0 9 1
R3816 7 8 1
R3817 7 0 1
R3818 3 0 1
R3819 3 3 1
R3820 1 6 1
R3821 1 5 1
R3822 0 0 1
R3823 7 4 1
R3824 5 9 1
R3825 2 4 1
R3826 1 1 1
R3827 5 5 1
R3828 5 7 1
R3829 7 8 1
R3830 7 2 1
R3831 3 0 1
R3832 9 2 1
R3833 1 1 1
R3834 7 3 1
R3835 8 1 1
R3836 8 5 1
R3837 0 1 1
R3838 0 7 1
R3839 2 7 1
R3840 4 8 1
R3841 5 3 1
R3842 1 1 1
R3843 9 9 1
R3844 7 0 1
R3845 5 7 1
R3846 1 7 1
R3847 4 1 1
R3848 3 6 1
R3849 0 0 1
R3850 7 3 1
R3851 5 2 1
R3852 0 1 1
R3853 7 2 1
R3854 7 5 1
R3855 0 0 1
R3856 1 3 1
R3857 9 0 1
R3858 4 7 1
R3859 5 3 1
R3860 2 5 1
R3861 0 2 1
R3862 7 9 1
R3863 3 7 1
R3864 2 0 1
R3865 5 9 1
R3866 5 2 1
R3867 0 3 1
R3868 1 0 1
R3869 6 5 1
R3870 7 5 1
R3871 5 6 1
R3872 4 7 1
R3873 7 9 1
R3874 0 3 1
R3875 9 7 1
R3876 8 6 1
R3877 8 1 1
R3878 9 4 1
R3879 2 4 1
R3880 6 4 1
R3881 6 5 1
R3882 1 2 1
R3883 0 9 1
R3884 9 0 1
R3885 4 9 1
R3886 0 4 1
R3887 7 1 1
R3888 2 6 1
R3889 8 7 1
R3890 3 0 1
R3891 2 3 1
R3892 5 5 1
R3893 3 3 1
R3894 1 5 1
R3895 6 5 1
R3896 4 3 1
R3897 9 6 1
R3898 4 4 1
R3899 5 4 1
R3900 0 9 1
R3901 9 4 1
R3902 0 8 1
R3903 9 7 1
R3904 3 4 1
R3905 3 1 1
R3906 7 8 1
R3907 1 3 1
R3908 1 4 1
R3909 5 5 1
R3910 0 0 1
R3911 5 9 1
R3912 3 0 1
R3913 3 1 1
R3914 5 1 1
R3915 6 5 1
R3916 2 6 1
R3917 0 1 1
R3918 6 3 1
R3919 2 1 1
R3920 2 2 1
R3921 9 6 1
R3922 1 9 1
R3923 8 5 1
R3924 0 8 1
R3925 1 9 1
R3926 3 9 1
R3927 8 5 1
R3928 7 3 1
R3929 7 3 1
R3930 4 9 1
R3931 8 3 1
R3932 7 0 1
R3933 3 0 1
R3934 4 8 1
R3935 1 2 1
R3936 0 2 1
R3937 6 4 1
R3938 3 0 1
R3939 2 3 1
R3940 7 8 1
R3941 7 8 1
R3942 2 3 1
R3943 9 9 1
R3944 2 2 1
R3945 8 0 1
R3946 0 4 1
R3947 8 4 1
R3948 8 6 1
R3949 4 0 1
R3950 7 1 1
R3951 9 4 1
R3952 1 2 1
R3953 7 5 1
R3954 0 3 1
R3955 5 9 1
R3956 4 2 1
R3957 7 1 1
R3958 8 1 1
R3959 5 5 1
R3960 6 1 1
R3961 1 9 1
R3962 5 6 1
R3963 5 1 1
R3964 7 8 1
R3965 7 6 1
R3966 6 2 1
R3967 4 2 1
R3968 5 4 1
R3969 1 9 1
R3970 5 8 1
R3971 6 6 1
R3972 1 2 1
R3973 8 4 1
R3974 5 7 1
R3975 9 6 1
R3976 9 5 1
R3977 4 3 1
R3978 7 5 1
R3979 2 3 1
R3980 8 3 1
R3981 6 0 1
R3982 7 6 1
R3983 6 3 1
R3984 7 7 1
R3985 1 6 1
R3986 0 8 1
R3987 5 3 1
R3988 4 3 1
R3989 0 5 1
R3990 3 1 1
R3991 4 9 1
R3992 2 0 1
R3993 5 7 1
R3994 2 6 1
R3995 0 8 1
R3996 9 3 1
R3997 4 9 1
R3998 4 7 1
R3999 8 9 1
R4000 9 4 1
R4001 4 6 1
R4002 3 2 1
R4003 9 5 1
R4004 5 1 1
R4005 0 5 1
R4006 4 3 1
R4007 7 3 1
R4008 8 4 1
R4009 6 7 1
R4010 6 2 1
R4011 8 2 1
R4012 0 6 1
R4013 2 6 1
R4014 4 8 1
R4015 0 4 1
R4016 8 7 1
R4017 5 7 1
R4018 6 6 1
R4019 7 8 1
R4020 4 0 1
R4021 3 7 1
R4022 0 9 1
R4023 3 2 1
R4024 5 2 1
R4025 2 3 1
R4026 5 1 1
R4027 8 6 1
R4028 7 5 1
R4029 3 1 1
R4030 2 5 1
R4031 7 5 1
R4032 2 6 1
R4033 7 7 1
R4034 9 8 1
R4035 0 4 1
R4036 5 5 1
R4037 6 6 1
R4038 8 5 1
R4039 7 3 1
R4040 2 2 1
R4041 2 0 1
R4042 7 3 1
R4043 3 5 1
R4044 4 8 1
R4045 5 1 1
R4046 4 4 1
R4047 0 9 1
R4048 2 5 1
R4049 2 6 1
R4050 9 4 1
R4051 9 2 1
R4052 0 6 1
R4053 2 2 1
R4054 8 1 1
R4055 9 1 1
R4056 3 9 1
R4057 7 3 1
R4058 5 8 1
R4059 4 3 1
R4060 3 9 1
R4061 9 7 1
R4062 7 8 1
R4063 4 1 1
R4064 4 3 1
R4065 5 7 1
R4066 0 4 1
R4067 4 3 1
R4068 1 5 1
R4069 5 5 1
R4070 3 4 1
R4071 6 8 1
R4072 2 6 1
R4073 6 0 1
R4074 5 5 1
R4075 4 5 1
R4076 1 6 1
R4077 2 7 1
R4078 7 3 1
R4079 8 6 1
R4080 8 8 1
R4081 1 3 1
R4082 2 2 1
R4083 8 7 1
R4084 1 1 1
R4085 0 3 1
R4086 0 9 1
R4087 5 0 1
R4088 5 6 1
R4089 9 4 1
R4090 4 7 1
R4091 0 6 1
R4092 0 4 1
R4093 9 3 1
R4094 6 5 1
R4095 2 8 1
R4096 8 0 1
R4097 3 5 1
R4098 7 2 1
R4099 3 5 1
R4100 0 0 1
R4101 6 0 1
R4102 7 1 1
R4103 5 2 1
R4104 1 9 1
R4105 2 6 1
R4106 5 6 1
R4107 7 7 1
R4108 0 2 1
R4109 9 0 1
R4110 4 1 1
R4111 5 3 1
R4112 1 2 1
R4113 4 9 1
R4114 5 9 1
R4115 4 2 1
R4116 0 0 1
R4117 4 8 1
R4118 2 4 1
R4119 1 3 1
R4120 4 1 1
R4121 6 8 1
R4122 7 0 1
R4123 6 0 1
R4124 9 6 1
R4125 8 3 1
R4126 5 6 1
R4127 3 0 1
R4128 3 7 1
R4129 5 3 1
R4130 8 4 1
R4131 7 0 1
R4132 5 6 1
R4133 4 9 1
R4134 1 8 1
R4135 0 7 1
R4136 7 8 1
R4137 1 7 1
R4138 3 5 1
R4139 1 1 1
R4140 1 6 1
R4141 9 3 1
R4142 3 8 1
R4143 7 8 1
R4144 1 3 1
R4145 5 0 1
R4146 8 4 1
R4147 5 6 1
R4148 5 9 1
R4149 8 9 1
R4150 6 2 1
R4151 1 9 1
R4152 2 1 1
R4153 8 4 1
R4154 7 8 1
R4155 3 0 1
R4156 4 6 1
R4157 4 1 1
R4158 2 5 1
R4159 1 3 1
R4160 8 0 1
R4161 5 3 1
R4162 5 1 1
R4163 3 3 1
R4164 8 7 1
R4165 8 6 1
R4166 0 7 1
R4167 3 4 1
R4168 4 5 1
R4169 4 9 1
R4170 6 5 1
R4171 0 5 1
R4172 4 9 1
R4173 7 1 1
R4174 0 3 1
R4175 0 2 1
R4176 4 5 1
R4177 4 9 1
R4178 9 4 1
R4179 1 7 1
R4180 2 6 1
R4181 6 3 1
R4182 2 4 1
R4183 5 8 1
R4184 5 5 1
R4185 8 7 1
R4186 5 8 1
R4187 5 4 1
R4188 8 1 1
R4189 1 1 1
R4190 0 0 1
R4191 9 6 1
R4192 5 4 1
R4193 8 8 1
R4194 5 3 1
R4195 2 5 1
R4196 4 7 1
R4197 7 3 1
R4198 2 3 1
R4199 9 0 1
R4200 7 5 1
R4201 9 9 1
R4202 6 0 1
R4203 4 8 1
R4204 9 2 1
R4205 4 4 1
R4206 8 3 1
R4207 2 3 1
R4208 3 9 1
R4209 6 3 1
R4210 5 0 1
R4211 6 8 1
R4212 6 8 1
R4213 5 3 1
R4214 1 0 1
R4215 6 1 1
R4216 0 4 1
R4217 0 1 1
R4218 0 2 1
R4219 9 4 1
R4220 9 7 1
R4221 8 1 1
R4222 9 1 1
R4223 0 4 1
R4224 6 0 1
R4225 1 9 1
R4226 8 4 1
R4227 4 0 1
R4228 8 1 1
R4229 5 3 1
R4230 3 5 1
R4231 5 3 1
R4232 0 4 1
R4233 8 7 1
R4234 5 0 1
R4235 0 9 1
R4236 7 3 1
R4237 9 0 1
R4238 6 6 1
R4239 3 2 1
R4240 0 8 1
R4241 8 4 1
R4242 3 7 1
R4243 4 5 1
R4244 3 2 1
R4245 9 7 1
R4246 2 0 1
R4247 3 7 1
R4248 6 3 1
R4249 9 2 1
R4250 7 8 1
R4251 8 9 1
R4252 3 4 1
R4253 8 8 1
R4254 3 2 1
R4255 4 3 1
R4256 7 0 1
R4257 2 7 1
R4258 7 3 1
R4259 5 6 1
R4260 0 2 1
R4261 3 8 1
R4262 4 3 1
R4263 9 2 1
R4264 2 8 1
R4265 2 3 1
R4266 4 1 1
R4267 5 4 1
R4268 5 4 1
R4269 9 0 1
R4270 8 1 1
R4271 3 6 1
R4272 8 8 1
R4273 6 6 1
R4274 9 0 1
R4275 0 2 1
R4276 2 2 1
R4277 4 5 1
R4278 8 4 1
R4279 1 8 1
R4280 2 5 1
R4281 4 7 1
R4282 8 9 1
R4283 7 5 1
R4284 3 8 1
R4285 9 6 1
R4286 2 2 1
R4287 7 0 1
R4288 5 2 1
R4289 1 3 1
R4290 7 3 1
R4291 8 0 1
R4292 8 4 1
R4293 5 1 1
R4294 2 3 1
R4295 2 2 1
R4296 1 0 1
R4297 4 3 1
R4298 0 4 1
R4299 6 1 1
R4300 6 6 1
R4301 6 9 1
R4302 0 4 1
R4303 3 5 1
R4304 0 4 1
R4305 1 3 1
R4306 2 3 1
R4307 4 5 1
R4308 6 6 1
R4309 6 9 1
R4310 5 6 1
R4311 6 2 1
R4312 7 1 1
R4313 1 9 1
R4314 0 6 1
R4315 3 7 1
R4316 0 0 1
R4317 9 4 1
R4318 6 9 1
R4319 0 1 1
R4320 3 7 1
R4321 1 4 1
R4322 8 4 1
R4323 2 9 1
R4324 0 2 1
R4325 3 3 1
R4326 1 5 1
R4327 2 3 1
R4328 9 5 1
R4329 8 1 1
R4330 9 0 1
R4331 1 3 1
R4332 6 8 1
R4333 3 7 1
R4334 5 7 1
R4335 3 5 1
R4336 8 5 1
R4337 4 2 1
R4338 6 8 1
R4339 1 4 1
R4340 1 3 1
R4341 5 7 1
R4342 7 2 1
R4343 8 2 1
R4344 0 1 1
R4345 2 6 1
R4346 0 5 1
R4347 9 9 1
R4348 5 5 1
R4349 3 4 1
R4350 7 0 1
R4351 8 4 1
R4352 7 0 1
R4353 5 5 1
R4354 2 9 1
R4355 9 9 1
R4356 5 9 1
R4357 0 0 1
R4358 3 3 1
R4359 7 1 1
R4360 0 7 1
R4361 3 3 1
R4362 7 5 1
R4363 4 5 1
R4364 9 0 1
R4365 6 4 1
R4366 4 7 1
R4367 6 1 1
R4368 8 3 1
R4369 5 4 1
R4370 9 0 1
R4371 5 1 1
R4372 5 6 1
R4373 1 7 1
R4374 1 9 1
R4375 0 7 1
R4376 2 3 1
R4377 4 2 1
R4378 8 8 1
R4379 0 1 1
R4380 3 1 1
R4381 3 8 1
R4382 0 0 1
R4383 1 4 1
R4384 6 3 1
R4385 9 4 1
R4386 7 6 1
R4387 9 0 1
R4388 2 3 1
R4389 7 8 1
R4390 5 5 1
R4391 0 4 1
R4392 4 5 1
R4393 1 2 1
R4394 9 0 1
R4395 7 5 1
R4396 4 4 1
R4397 8 9 1
R4398 5 1 1
R4399 6 6 1
R4400 1 8 1
R4401 2 7 1
R4402 1 2 1
R4403 0 3 1
R4404 3 4 1
R4405 7 4 1
R4406 9 7 1
R4407 0 7 1
R4408 1 2 1
R4409 4 6 1
R4410 0 6 1
R4411 8 5 1
R4412 5 9 1
R4413 4 5 1
R4414 2 1 1
R4415 3 0 1
R4416 0 8 1
R4417 7 5 1
R4418 5 1 1
R4419 9 7 1
R4420 9 2 1
R4421 8 7 1
R4422 2 7 1
R4423 6 3 1
R4424 3 7 1
R4425 0 6 1
R4426 2 6 1
R4427 3 3 1
R4428 9 3 1
R4429 1 9 1
R4430 1 6 1
R4431 9 2 1
R4432 0 4 1
R4433 9 2 1
R4434 6 8 1
R4435 8 0 1
R4436 2 2 1
R4437 9 4 1
R4438 0 2 1
R4439 7 2 1
R4440 5 6 1
R4441 8 6 1
R4442 9 8 1
R4443 1 9 1
R4444 4 3 1
R4445 5 8 1
R4446 7 5 1
R4447 9 5 1
R4448 9 4 1
R4449 2 9 1
R4450 0 2 1
R4451 0 8 1
R4452 7 7 1
R4453 3 4 1
R4454 4 8 1
R4455 5 1 1
R4456 8 3 1
R4457 7 5 1
R4458 1 7 1
R4459 3 7 1
R4460 3 1 1
R4461 1 4 1
R4462 4 3 1
R4463 5 7 1
R4464 7 8 1
R4465 5 6 1
R4466 2 2 1
R4467 5 4 1
R4468 8 9 1
R4469 0 9 1
R4470 4 9 1
R4471 2 3 1
R4472 7 6 1
R4473 0 6 1
R4474 5 4 1
R4475 2 9 1
R4476 0 3 1
R4477 6 0 1
R4478 3 3 1
R4479 8 9 1
R4480 6 8 1
R4481 1 1 1
R4482 8 1 1
R4483 0 0 1
R4484 2 4 1
R4485 9 4 1
R4486 7 5 1
R4487 5 8 1
R4488 1 4 1
R4489 5 6 1
R4490 1 7 1
R4491 1 3 1
R4492 1 3 1
R4493 1 0 1
R4494 0 1 1
R4495 2 1 1
R4496 8 5 1
R4497 7 1 1
R4498 6 1 1
R4499 9 2 1
R4500 5 8 1
R4501 9 6 1
R4502 3 5 1
R4503 7 9 1
R4504 4 3 1
R4505 2 8 1
R4506 6 4 1
R4507 9 0 1
R4508 0 6 1
R4509 9 7 1
R4510 7 3 1
R4511 4 4 1
R4512 8 8 1
R4513 4 7 1
R4514 4 0 1
R4515 7 0 1
R4516 4 5 1
R4517 5 8 1
R4518 2 2 1
R4519 9 3 1
R4520 5 1 1
R4521 1 8 1
R4522 1 6 1
R4523 5 3 1
R4524 7 8 1
R4525 6 0 1
R4526 3 5 1
R4527 0 1 1
R4528 2 1 1
R4529 9 3 1
R4530 4 3 1
R4531 1 5 1
R4532 4 1 1
R4533 6 0 1
R4534 7 8 1
R4535 4 2 1
R4536 2 9 1
R4537 7 6 1
R4538 4 9 1
R4539 1 8 1
R4540 0 3 1
R4541 7 5 1
R4542 5 1 1
R4543 1 0 1
R4544 0 6 1
R4545 1 5 1
R4546 1 0 1
R4547 4 4 1
R4548 9 0 1
R4549 5 0 1
R4550 2 7 1
R4551 4 1 1
R4552 1 1 1
R4553 9 9 1
R4554 4 9 1
R4555 2 1 1
R4556 3 6 1
R4557 5 6 1
R4558 5 3 1
R4559 2 0 1
R4560 6 3 1
R4561 4 2 1
R4562 5 7 1
R4563 7 1 1
R4564 6 9 1
R4565 9 5 1
R4566 4 1 1
R4567 5 2 1
R4568 6 8 1
R4569 0 8 1
R4570 1 0 1
R4571 9 0 1
R4572 8 9 1
R4573 1 2 1
R4574 2 3 1
R4575 2 2 1
R4576 6 5 1
R4577 1 2 1
R4578 5 1 1
R4579 0 0 1
R4580 9 3 1
R4581 1 0 1
R4582 9 9 1
R4583 9 2 1
R4584 9 6 1
R4585 7 4 1
R4586 4 5 1
R4587 3 2 1
R4588 2 9 1
R4589 8 7 1
R4590 2 8 1
R4591 4 3 1
R4592 0 8 1
R4593 1 1 1
R4594 5 2 1
R4595 6 5 1
R4596 6 2 1
R4597 2 7 1
R4598 8 1 1
R4599 1 6 1
R4600 2 3 1
R4601 2 9 1
R4602 1 5 1
R4603 1 9 1
R4604 5 0 1
R4605 9 1 1
R4606 7 9 1
R4607 9 9 1
R4608 2 0 1
R4609 5 3 1
R4610 8 9 1
R4611 7 6 1
R4612 0 0 1
R4613 6 3 1
R4614 7 3 1
R4615 2 2 1
R4616 3 4 1
R4617 7 5 1
R4618 2 0 1
R4619 8 9 1
R4620 8 6 1
R4621 5 2 1
R4622 7 2 1
R4623 2 2 1
R4624 8 8 1
R4625 4 5 1
R4626 0 8 1
R4627 9 7 1
R4628 7 6 1
R4629 2 1 1
R4630 4 6 1
R4631 3 1 1
R4632 0 3 1
R4633 7 2 1
R4634 7 4 1
R4635 9 5 1
R4636 2 8 1
R4637 5 3 1
R4638 4 3 1
R4639 5 3 1
R4640 6 3 1
R4641 9 6 1
R4642 9 9 1
R4643 5 8 1
R4644 3 6 1
R4645 1 9 1
R4646 7 7 1
R4647 3 9 1
R4648 5 3 1
R4649 0 8 1
R4650 0 7 1
R4651 2 2 1
R4652 5 8 1
R4653 2 5 1
R4654 2 7 1
R4655 3 3 1
R4656 3 3 1
R4657 5 6 1
R4658 1 1 1
R4659 0 5 1
R4660 0 8 1
R4661 2 8 1
R4662 6 8 1
R4663 4 9 1
R4664 9 2 1
R4665 7 7 1
R4666 3 8 1
R4667 2 0 1
R4668 1 9 1
R4669 0 0 1
R4670 1 6 1
R4671 3 6 1
R4672 1 0 1
R4673 5 9 1
R4674 9 8 1
R4675 7 4 1
R4676 6 1 1
R4677 2 5 1
R4678 6 7 1
R4679 0 4 1
R4680 4 0 1
R4681 7 4 1
R4682 4 7 1
R4683 5 8 1
R4684 5 5 1
R4685 0 2 1
R4686 5 2 1
R4687 8 7 1
R4688 9 7 1
R4689 2 3 1
R4690 1 4 1
R4691 1 7 1
R4692 4 3 1
R4693 8 0 1
R4694 3 5 1
R4695 2 8 1
R4696 8 2 1
R4697 7 6 1
R4698 0 8 1
R4699 7 2 1
R4700 6 0 1
R4701 5 1 1
R4702 3 6 1
R4703 5 9 1
R4704 4 2 1
R4705 4 7 1
R4706 2 2 1
R4707 2 2 1
R4708 6 4 1
R4709 7 8 1
R4710 8 2 1
R4711 6 0 1
R4712 5 6 1
R4713 6 6 1
R4714 1 0 1
R4715 1 9 1
R4716 0 7 1
R4717 6 4 1
R4718 7 2 1
R4719 7 2 1
R4720 6 7 1
R4721 4 3 1
R4722 9 2 1
R4723 8 9 1
R4724 1 1 1
R4725 3 5 1
R4726 5 8 1
R4727 5 3 1
R4728 5 5 1
R4729 9 8 1
R4730 7 5 1
R4731 8 6 1
R4732 0 0 1
R4733 2 9 1
R4734 8 6 1
R4735 5 5 1
R4736 7 2 1
R4737 1 7 1
R4738 4 8 1
R4739 2 5 1
R4740 1 4 1
R4741 1 4 1
R4742 5 7 1
R4743 4 9 1
R4744 8 7 1
R4745 1 7 1
R4746 8 4 1
R4747 2 7 1
R4748 8 5 1
R4749 0 8 1
R4750 1 9 1
R4751 1 9 1
R4752 2 0 1
R4753 6 0 1
R4754 9 5 1
R4755 2 3 1
R4756 1 4 1
R4757 6 4 1
R4758 2 6 1
R4759 8 5 1
R4760 4 6 1
R4761 8 3 1
R4762 0 4 1
R4763 1 9 1
R4764 4 7 1
R4765 1 2 1
R4766 2 5 1
R4767 6 2 1
R4768 1 6 1
R4769 8 7 1
R4770 0 2 1
R4771 5 6 1
R4772 5 1 1
R4773 7 3 1
R4774 4 0 1
R4775 8 6 1
R4776 6 9 1
R4777 1 1 1
R4778 7 8 1
R4779 8 9 1
R4780 2 0 1
R4781 1 3 1
R4782 5 7 1
R4783 9 5 1
R4784 3 0 1
R4785 4 6 1
R4786 3 5 1
R4787 0 0 1
R4788 7 3 1
R4789 7 8 1
R4790 8 7 1
R4791 7 6 1
R4792 8 4 1
R4793 5 4 1
R4794 7 0 1
R4795 9 6 1
R4796 8 0 1
R4797 5 6 1
R4798 1 5 1
R4799 9 5 1
R4800 6 6 1
R4801 3 4 1
R4802 5 8 1
R4803 0 5 1
R4804 0 3 1
R4805 7 9 1
R4806 0 5 1
R4807 4 8 1
R4808 8 7 1
R4809 7 0 1
R4810 6 6 1
R4811 5 6 1
R4812 8 2 1
R4813 7 8 1
R4814 0 7 1
R4815 3 0 1
R4816 9 2 1
R4817 9 7 1
R4818 3 5 1
R4819 0 8 1
R4820 0 1 1
R4821 6 3 1
R4822 5 2 1
R4823 3 6 1
R4824 2 4 1
R4825 2 0 1
R4826 9 0 1
R4827 8 5 1
R4828 1 3 1
R4829 3 9 1
R4830 1 4 1
R4831 0 4 1
R4832 2 7 1
R4833 7 2 1
R4834 1 8 1
R4835 8 6 1
R4836 8 1 1
R4837 2 5 1
R4838 3 5 1
R4839 5 5 1
R4840 0 4 1
R4841 9 8 1
R4842 2 0 1
R4843 0 0 1
R4844 3 1 1
R4845 6 2 1
R4846 0 8 1
R4847 1 0 1
R4848 9 7 1
R4849 4 0 1
R4850 0 9 1
R4851 1 5 1
R4852 8 0 1
R4853 4 4 1
R4854 1 2 1
R4855 5 4 1
R4856 0 4 1
R4857 5 1 1
R4858 0 8 1
R4859 1 6 1
R4860 7 0 1
R4861 7 4 1
R4862 0 7 1
R4863 7 9 1
R4864 2 0 1
R4865 9 1 1
R4866 6 4 1
R4867 8 4 1
R4868 7 1 1
R4869 6 2 1
R4870 1 1 1
R4871 6 5 1
R4872 8 4 1
R4873 0 6 1
R4874 0 4 1
R4875 1 7 1
R4876 8 8 1
R4877 7 4 1
R4878 9 6 1
R4879 7 0 1
R4880 8 5 1
R4881 7 4 1
R4882 9 1 1
R4883 4 4 1
R4884 7 0 1
R4885 7 7 1
R4886 1 2 1
R4887 7 3 1
R4888 6 2 1
R4889 7 7 1
R4890 4 0 1
R4891 7 2 1
R4892 4 3 1
R4893 1 2 1
R4894 3 3 1
R4895 7 5 1
R4896 3 1 1
R4897 7 6 1
R4898 1 4 1
R4899 1 3 1
R4900 8 5 1
R4901 1 3 1
R4902 1 3 1
R4903 9 2 1
R4904 1 6 1
R4905 6 1 1
R4906 4 6 1
R4907 4 0 1
R4908 9 3 1
R4909 1 0 1
R4910 2 0 1
R4911 8 2 1
R4912 6 8 1
R4913 4 7 1
R4914 8 7 1
R4915 1 4 1
R4916 6 2 1
R4917 1 4 1
R4918 9 7 1
R4919 9 9 1
R4920 5 5 1
R4921 8 1 1
R4922 7 9 1
R4923 3 3 1
R4924 3 4 1
R4925 2 1 1
R4926 9 2 1
R4927 1 1 1
R4928 8 2 1
R4929 3 4 1
R4930 2 1 1
R4931 2 4 1
R4932 5 3 1
R4933 2 0 1
R4934 0 7 1
R4935 0 9 1
R4936 3 0 1
R4937 1 1 1
R4938 2 6 1
R4939 8 2 1
R4940 0 7 1
R4941 7 2 1
R4942 2 8 1
R4943 5 0 1
R4944 1 6 1
R4945 5 4 1
R4946 4 7 1
R4947 8 3 1
R4948 4 1 1
R4949 4 2 1
R4950 4 0 1
R4951 3 4 1
R4952 0 9 1
R4953 7 4 1
R4954 5 2 1
R4955 2 2 1
R4956 9 9 1
R4957 2 6 1
R4958 0 2 1
R4959 3 9 1
R4960 7 8 1
R4961 4 1 1
R4962 6 7 1
R4963 8 4 1
R4964 9 9 1
R4965 8 7 1
R4966 6 2 1
R4967 0 1 1
R4968 0 4 1
R4969 4 4 1
R4970 9 9 1
R4971 0 3 1
R4972 0 9 1
R4973 9 9 1
R4974 4 0 1
R4975 0 2 1
R4976 0 0 1
R4977 3 6 1
R4978 3 9 1
R4979 7 2 1
R4980 5 5 1
R4981 4 6 1
R4982 4 7 1
R4983 4 9 1
R4984 7 5 1
R4985 9 2 1
R4986 8 3 1
R4987 3 5 1
R4988 9 7 1
R4989 5 7 1
R4990 6 1 1
R4991 5 1 1
R4992 8 2 1
R4993 1 7 1
R4994 4 2 1
R4995 1 7 1
R4996 8 9 1
R4997 1 5 1
R4998 7 3 1
R4999 8 4 1
